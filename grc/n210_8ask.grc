options:
  parameters:
    id: n210_8ask
    title: 8-ASK over the air | USRP N210 loopback
    generate_options: qt_gui
    output_language: python
    author: Antenna benchmark
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, alpha, 11*sps*nfilts)
  states: {}
- name: const
  id: variable_constellation_rect
  parameters:
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    const_points: '[-7, -5, -3, -1, 1, 3, 5, 7]'
    rot_sym: '1'
    real_sect: '8'
    imag_sect: '1'
    w_real_sect: '2'
    w_imag_sect: '1'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: warmup_bits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: k
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    value: 1e6
    type: eng_float
    label: Symbol rate (symbols/s)
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: symbol_rate*k
  states: {}
- name: rrc_bandwidth
  id: variable
  parameters:
    value: symbol_rate*(1+alpha)
  states: {}
- name: random_bytes
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '256'
    num_samps: '32768'
    repeat: 'True'
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    samples_per_symbol: sps
    excess_bw: alpha
  states: {}
- name: clock_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: decoded_link
  id: virtual_sink
  parameters:
    stream_id: decoded
  states: {}
- name: reference_link
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: decoded_source
  id: virtual_source
  parameters:
    stream_id: decoded
  states: {}
- name: diff_decoder
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits+data_period_bits
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    type: byte
    delay: data_period_bits
  states: {}
- name: skip_tx
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits+data_period_bits
  states: {}
- name: xor
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: errors_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: integrate
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: ber_window
  states: {}
- name: ber_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 0.5/ber_window
  states: {}
- name: ber_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: BER estimate | RX vs RX one data period earlier, /2
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    label1: Bit error ratio
    unit1: errors/bit
    gui_hint: views@0:0,0,1,1
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: After adaptive LMS equalization | symbols and guides
    size: '1024'
    nconnections: '3'
    grid: 'True'
    gui_hint: views@0:2,0,1,1
    label1: RX symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    color2: '"black"'
    color3: '"dark green"'
    marker2: '8'
    alpha1: '0.3'
    alpha3: '0.5'
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: TX and RX baseband spectrum | relative dB
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: samp_rate
    nconnections: '2'
    gui_hint: views@1:2,0,1,1
    label1: RX
    label2: TX
  states: {}
- name: waveform
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: TX and RX waveform | I/Q
    size: '512'
    srate: samp_rate
    nconnections: '2'
    gui_hint: views@1:1,1,1,1
    label1: RX I
    label2: RX Q
    label3: TX I
    label4: TX Q
  states: {}
- name: evm
  id: digital_meas_evm_cc
  parameters:
    cons: const
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: evm_rms
  id: blocks_rms_xx
  parameters:
    type: float
    alpha: '0.001'
  states: {}
- name: evm_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: Decision-directed RMS EVM
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    max: '100'
    label1: Decision-directed EVM
    unit1: '%'
    gui_hint: views@0:0,1,1,1
  states: {}
- name: scope
  id: note
  parameters:
    note: 'SISO single carrier, RRC pulse shaping. 8ASK, 4 samples/symbol. No carrier recovery: leave frequency offset=0 and epsilon=1 for scored BER. Delay calibrated for this filter/clock configuration. See README.md.'
  states: {}
- name: rx_iq_link
  id: virtual_sink
  parameters:
    stream_id: rx_iq
  states: {}
- name: symbols_link
  id: virtual_sink
  parameters:
    stream_id: rx_symbols
  states: {}
- name: symbols_plot
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: spectrum_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: waveform_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: evm_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: symbol_rms
  id: variable
  parameters:
    value: (sum(abs(p)**2 for p in const.points())/len(const.points()))**0.5
  states: {}
- name: tx_power
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_amplitude/symbol_rms
  states: {}
- name: rx_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    num_tabs: '6'
    label0: Constellations
    label1: Waveforms
    label2: I eyes
    label3: RF levels
    label4: Q eyes
    label5: BER / EVM / taps
  states: {}
- name: tx_plot_link
  id: virtual_sink
  parameters:
    stream_id: tx_iq
  states: {}
- name: timing_link
  id: virtual_sink
  parameters:
    stream_id: timing_error
  states: {}
- name: ber_link
  id: virtual_sink
  parameters:
    stream_id: ber_history
  states: {}
- name: evm_link
  id: virtual_sink
  parameters:
    stream_id: evm_history
  states: {}
- name: tx_spectrum
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_time
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: ber_plot_input
  id: virtual_source
  parameters:
    stream_id: ber_history
  states: {}
- name: ber_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Self-referenced BER estimate per window
    size: '128'
    srate: bit_rate/ber_window
    autoscale: 'True'
    gui_hint: views@5:1,0,1,1
    ylabel: Bit error ratio
    yunit: ''
    label1: BER
    ymin: '0'
  states: {}
- name: evm_plot_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: evm_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Smoothed decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@5:1,1,1,1
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
  states: {}
- name: timing_input
  id: virtual_source
  parameters:
    stream_id: timing_error
  states: {}
- name: timing_error
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Clock sync timing error
    size: '512'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@1:2,1,1,1
  states: {}
- name: eye_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: views@2:1,1,1,1
    ylabel: RX in-phase amplitude
    label1: RX I | raw N210 RX output
  states: {}
- name: unused_timing_states
  id: blocks_null_sink
  parameters:
    type: float
    num_inputs: '2'
  states: {}
- name: tx_level_dbfs
  id: parameter
  parameters:
    value: '-15'
    type: eng_float
    label: TX digital RMS level (dBFS, keep peaks < 0)
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    value: 10**(tx_level_dbfs/20.0)
  states: {}
- name: rx_level
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 10**(rx_gain_db/20.0)
  states: {}
- name: tx_meter_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: tx_power_sum
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '4096'
  states: {}
- name: tx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 1.0/4096
  states: {}
- name: tx_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: tx_power_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: TX digital average level
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-200'
    max: '100'
    label1: TX digital average level
    unit1: dBFS
    gui_hint: views@3:3,0,1,1
  states: {}
- name: rx_meter_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: rx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_power_sum
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '4096'
  states: {}
- name: rx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 1.0/4096
  states: {}
- name: rx_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: rx_power_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: 'RX ADC level: signal + noise'
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-200'
    max: '100'
    label1: 'RX ADC level: signal + noise'
    unit1: dBFS
    gui_hint: views@3:3,1,1,1
  states: {}
- name: power_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Digital levels | TX average and RX ADC (dBFS)
    size: '128'
    srate: samp_rate/4096
    nconnections: '2'
    autoscale: 'True'
    label1: TX average (dBFS)
    label2: RX ADC total (dBFS)
    gui_hint: views@3:1,0,1,1
  states: {}
- name: tx_peak_vectors
  id: blocks_stream_to_vector
  parameters:
    type: float
    num_items: '4096'
  states: {}
- name: tx_peak_mw
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '4096'
    vlen_out: '1'
  states: {}
- name: tx_peak_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: peak_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: TX sampled peak (must stay below 0 dBFS)
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-200'
    max: '100'
    label1: TX sampled peak (must stay below 0 dBFS)
    unit1: dBFS
    gui_hint: views@3:4,0,1,1
  states: {}
- name: envelope_floor
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1e-30'
  states: {}
- name: envelope_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: envelope_plot
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: TX sampled power envelope (dBFS)
    size: '512'
    srate: samp_rate
    autoscale: 'True'
    gui_hint: views@3:1,1,1,1
  states: {}
- name: tx_mw_link
  id: virtual_sink
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: peak_input
  id: virtual_source
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: envelope_input
  id: virtual_source
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: chart_math
  id: import
  parameters:
    imports: |-
      import math
      import numpy
  states: {}
- name: evm_guide_percent
  id: parameter
  parameters:
    value: '5'
    type: eng_float
    label: Constellation guide radius (% RMS)
  states: {}
- name: rx_snr
  id: blocks_nlog10_ff
  parameters:
    n: '-20'
    k: '40'
  states: {}
- name: snr_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: MER from decision-directed EVM (Es/N0 estimate)
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-100'
    max: '100'
    label1: MER from decision-directed EVM (Es/N0 estimate)
    unit1: dB
    gui_hint: views@3:4,1,1,1
  states: {}
- name: rx_ebno
  id: blocks_nlog10_ff
  parameters:
    n: '-20'
    k: 40-10*math.log10(k)
  states: {}
- name: ebno_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: Eb/N0 estimate from MER
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '-100'
    max: '100'
    label1: Eb/N0 estimate from MER
    unit1: dB
    gui_hint: views@3:5,0,1,1
  states: {}
- name: tx_symbol_input
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: tx_symbol_chunks
  id: blocks_packed_to_unpacked_xx
  parameters:
    type: byte
    bits_per_chunk: k
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: tx_symbol_diff
  id: digital_diff_encoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: tx_symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: const.points()
    dimension: '1'
  states: {}
- name: tx_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: 'TX before RRC: blue symbols / black ideal / green guide'
    size: '1024'
    nconnections: '3'
    grid: 'True'
    gui_hint: views@0:1,0,1,1
    label1: TX encoded symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    color2: '"black"'
    color3: '"dark green"'
    marker2: '8'
    alpha1: '0.3'
    alpha3: '0.5'
  states: {}
- name: ideal_symbols
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: const.points()
    repeat: 'True'
  states: {}
- name: evm_circles
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: '[p+symbol_rms*evm_guide_percent/100*complex(math.cos(t),math.sin(t)) for p in const.points() for t in numpy.linspace(0,2*math.pi,64,endpoint=False)]'
    repeat: 'True'
  states: {}
- name: eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: eye_quadrature
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: views@4:1,1,1,1
    ylabel: RX quadrature amplitude
    label1: RX Q | raw N210 RX output
  states: {}
- name: square_plot_panels
  id: snippet
  parameters:
    section: main_after_init
    code: |
      # Plot layout is a resizable 2x2 grid, not a square-canvas constraint.
      for index in range(self.views.count()):
          layout = getattr(self, "views_grid_layout_"+str(index))
          if layout is not None:
              layout.setColumnStretch(0, 1)
              layout.setColumnStretch(1, 1)
              layout.setRowStretch(1, 1)
              layout.setRowStretch(2, 1)
              # Native sinks otherwise request a large minimum and force scrolling.
              for row in (1, 2):
                  for column in (0, 1):
                      panel = layout.itemAtPosition(row, column).widget()
                      panel.setMinimumSize(0, 0)
                      panel.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.views.setMinimumSize(0, 0)
      self.views.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.resize(1180, 900)
    comment: 'UI layout only: resizable 2x2 dashboards.'
  states: {}
- name: ideal_symbols_link
  id: virtual_sink
  parameters:
    stream_id: ideal_points
  states: {}
- name: evm_circles_link
  id: virtual_sink
  parameters:
    stream_id: guide_circles
  states: {}
- name: tx_dbm_link
  id: virtual_sink
  parameters:
    stream_id: sensed_tx_dbm
  states: {}
- name: constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: tx_constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: tx_constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: rx_snr_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: rx_ebno_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: eye_q_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eq_taps
  id: parameter
  parameters:
    value: '11'
    type: intx
    label: Adaptive equalizer taps
  states: {}
- name: eq_step
  id: parameter
  parameters:
    value: '0.01'
    type: eng_float
    label: NLMS adaptation step
  states: {}
- name: eq_algorithm
  id: variable_adaptive_algorithm
  parameters:
    type: lms
    cons: const
    step_size: eq_step/(eq_taps*symbol_rms**2)
  states: {}
- name: equalizer
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: pre_eq_link
  id: virtual_sink
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: before_eq_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: before_eq_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: 'Middle: timed symbols before adaptive EQ'
    size: '1024'
    grid: 'True'
    gui_hint: views@0:1,1,1,1
  states: {}
- name: eye_synthesis_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps,sps,1.0,alpha,11*sps)
  states: {}
- name: middle_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: middle_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: eye_synthesis_taps
  states: {}
- name: middle_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: middle_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: MIDDLE I | reconstructed
    gui_hint: views@2:2,0,1,1
    label1: Middle I | before EQ, reconstructed
  states: {}
- name: middle_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: middle_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: MIDDLE Q | reconstructed
    gui_hint: views@4:2,0,1,1
    label1: Middle Q | before EQ, reconstructed
  states: {}
- name: after_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: after_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: eye_synthesis_taps
  states: {}
- name: after_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: after_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: AFTER I | reconstructed
    gui_hint: views@2:2,1,1,1
    label1: After EQ I | reconstructed
  states: {}
- name: after_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: after_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: AFTER Q | reconstructed
    gui_hint: views@4:2,1,1,1
    label1: After EQ Q | reconstructed
  states: {}
- name: tx_eye_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: tx_eye_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: TX_EYE I | TX shaped
    gui_hint: views@2:1,0,1,1
    label1: TX I | shaped waveform
  states: {}
- name: tx_eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: tx_eye_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: TX_EYE Q | TX shaped
    gui_hint: views@4:1,0,1,1
    label1: TX Q | shaped waveform
  states: {}
- name: tx_wave_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_waveform
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: Clean TX waveform | I/Q
    size: '512'
    srate: samp_rate
    gui_hint: views@1:1,0,1,1
  states: {}
- name: evm_meter_history_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: eq_evm_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Equalized decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@0:2,1,1,1
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
  states: {}
- name: spectrum_budget
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: RX spectrum | relative level
    gui_hint: views@3:2,0,1,1
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: samp_rate
  states: {}
- name: power_reference_chart
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: MER history (dB)
    gui_hint: views@3:2,1,1,1
    size: '128'
    srate: samp_rate/4096
    autoscale: 'True'
  states: {}
- name: eq_error_trace
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Per-symbol equalized EVM (%)
    gui_hint: views@5:2,0,1,1
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
  states: {}
- name: equalizer_initial_taps
  id: snippet
  parameters:
    section: main_after_init
    code: self.equalizer.set_taps([0j]*((self.eq_taps-1)//2)+[1+0j]+[0j]*(self.eq_taps//2))
  states: {}
- name: eq_delay_symbols
  id: variable
  parameters:
    value: (eq_taps-1)//2
  states: {}
- name: eq_tap_decimator
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    vlen: eq_taps
    n: '1000'
  states: {}
- name: eq_tap_magnitudes
  id: blocks_complex_to_mag
  parameters:
    vlen: eq_taps
  states: {}
- name: eq_tap_plot
  id: qtgui_vector_sink_f
  parameters:
    name: Adaptive LMS tap magnitudes | updated during convergence
    vlen: eq_taps
    x_start: '0'
    x_step: '1'
    x_axis_label: Tap index
    y_axis_label: Magnitude
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@5:2,1,1,1
  states: {}
- name: spectrum_budget_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: snr_history_link
  id: virtual_sink
  parameters:
    stream_id: snr_history
  states: {}
- name: power_reference_chart_input
  id: virtual_source
  parameters:
    stream_id: snr_history
  states: {}
- name: evm_per_symbol_link
  id: virtual_sink
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: eq_error_trace_input
  id: virtual_source
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: adaptive_tap_vectors_link
  id: virtual_sink
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: eq_tap_decimator_input
  id: virtual_source
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: section_controls
  id: note
  parameters:
    note: CONTROLS & RF SETTINGS
  states: {}
- name: section_transmitter
  id: note
  parameters:
    note: TRANSMITTER
  states: {}
- name: section_channel
  id: note
  parameters:
    note: N210 RF FRONT END
  states: {}
- name: section_receiver
  id: note
  parameters:
    note: RECEIVER
  states: {}
- name: section_ber
  id: note
  parameters:
    note: BER MEASUREMENT
  states: {}
- name: section_rx_diagnostics
  id: note
  parameters:
    note: RX DIAGNOSTICS
  states: {}
- name: section_power
  id: note
  parameters:
    note: LINK BUDGET & POWER METERS
  states: {}
- name: section_reference
  id: note
  parameters:
    note: TX SYMBOL REFERENCE & EVM GUIDES
  states: {}
- name: section_pre_eq
  id: note
  parameters:
    note: BEFORE EQUALIZATION
  states: {}
- name: section_eyes
  id: note
  parameters:
    note: 'EYE COMPARISON: MIDDLE / AFTER EQ / TX'
  states: {}
- name: section_extra_plots
  id: note
  parameters:
    note: LIVE WAVEFORM & ADAPTATION MONITORS
  states: {}
- name: usrp_address
  id: parameter
  parameters:
    value: addr=192.168.10.2
    type: str
    label: N210 device address
  states: {}
- name: center_freq_hz
  id: parameter
  parameters:
    value: 915e6
    type: eng_float
    label: RF center frequency (Hz)
  states: {}
- name: tx_gain_norm
  id: variable_qtgui_range
  parameters:
    value: '0.5'
    start: '0'
    stop: '1'
    step: '0.01'
    label: TX gain (normalized 0-1)
  states: {}
- name: rx_gain_norm
  id: variable_qtgui_range
  parameters:
    value: '0.5'
    start: '0'
    stop: '1'
    step: '0.01'
    label: RX gain (normalized 0-1)
  states: {}
- name: phase_fix_deg
  id: variable_qtgui_range
  parameters:
    value: '0'
    start: '0'
    stop: '270'
    step: '180'
    label: Phase-ambiguity rotation (deg)
  states: {}
- name: rx_gain_db
  id: parameter
  parameters:
    value: '75'
    type: eng_float
    label: Fixed RX digital gain (dB) = -(RX ADC dBFS)
  states: {}
- name: carrier_loop_bw
  id: variable
  parameters:
    value: 2*math.pi/200
  states: {}
- name: data_period_bits
  id: variable
  parameters:
    value: 8*32768
  states: {}
- name: usrp_tx
  id: uhd_usrp_sink
  parameters:
    type: fc32
    otw: sc16
    dev_addr: usrp_address
    dev_args: '""'
    sync: none
    samp_rate: samp_rate
    center_freq0: center_freq_hz
    gain0: tx_gain_norm
    gain_type0: normalized
    ant0: '"TX/RX"'
  states: {}
- name: usrp_rx
  id: uhd_usrp_source
  parameters:
    type: fc32
    otw: sc16
    dev_addr: usrp_address
    dev_args: '""'
    sync: none
    samp_rate: samp_rate
    center_freq0: center_freq_hz
    rx_agc0: Disabled
    gain0: rx_gain_norm
    gain_type0: normalized
    ant0: '"RX2"'
    dc_offs_enb0: auto
    iq_imbal_enb0: auto
  states: {}
- name: carrier_sync
  id: digital_costas_loop_cc
  parameters:
    w: carrier_loop_bw
    order: '2'
  states: {}
- name: phase_fix
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: complex(math.cos(math.radians(phase_fix_deg)),math.sin(math.radians(phase_fix_deg)))
  states: {}

connections:
- [random_bytes, '0', modulator, '0']
- [modulator, '0', tx_power, '0']
- [phase_fix, '0', decoder, '0']
- [decoder, '0', decoded_link, '0']
- [random_bytes, '0', reference_link, '0']
- [decoded_source, '0', diff_decoder, '0']
- [diff_decoder, '0', unpack_rx, '0']
- [unpack_rx, '0', skip_rx, '0']
- [delay, '0', skip_tx, '0']
- [skip_rx, '0', xor, '0']
- [xor, '0', errors_float, '0']
- [errors_float, '0', integrate, '0']
- [integrate, '0', ber_scale, '0']
- [ber_scale, '0', ber_display, '0']
- [skip_tx, '0', xor, '1']
- [evm, '0', evm_rms, '0']
- [evm_rms, '0', evm_display, '0']
- [phase_fix, '0', symbols_link, '0']
- [symbols_plot, '0', constellation, '0']
- [spectrum_input, '0', spectrum, '0']
- [waveform_input, '0', waveform, '0']
- [evm_input, '0', evm, '0']
- [tx_power, '0', tx_plot_link, '0']
- [clock_sync, '1', timing_link, '0']
- [ber_scale, '0', ber_link, '0']
- [evm_rms, '0', evm_link, '0']
- [tx_spectrum, '0', spectrum, '1']
- [tx_time, '0', waveform, '1']
- [ber_plot_input, '0', ber_history, '0']
- [evm_plot_input, '0', evm_history, '0']
- [timing_input, '0', timing_error, '0']
- [clock_sync, '2', unused_timing_states, '0']
- [clock_sync, '3', unused_timing_states, '1']
- [rx_level, '0', clock_sync, '0']
- [tx_meter_input, '0', tx_milliwatts, '0']
- [tx_milliwatts, '0', tx_power_sum, '0']
- [tx_power_sum, '0', tx_power_mean, '0']
- [tx_power_mean, '0', tx_dbm, '0']
- [tx_dbm, '0', tx_power_display, '0']
- [rx_meter_input, '0', rx_milliwatts, '0']
- [rx_milliwatts, '0', rx_power_sum, '0']
- [rx_power_sum, '0', rx_power_mean, '0']
- [rx_power_mean, '0', rx_dbm, '0']
- [rx_dbm, '0', rx_power_display, '0']
- [tx_dbm, '0', power_history, '0']
- [rx_dbm, '0', power_history, '1']
- [tx_peak_vectors, '0', tx_peak_mw, '0']
- [tx_peak_mw, '0', tx_peak_dbm, '0']
- [tx_peak_dbm, '0', peak_display, '0']
- [envelope_floor, '0', envelope_dbm, '0']
- [envelope_dbm, '0', envelope_plot, '0']
- [tx_milliwatts, '0', tx_mw_link, '0']
- [peak_input, '0', tx_peak_vectors, '0']
- [envelope_input, '0', envelope_floor, '0']
- [rx_snr, '0', snr_display, '0']
- [rx_ebno, '0', ebno_display, '0']
- [tx_symbol_input, '0', tx_symbol_chunks, '0']
- [tx_symbol_chunks, '0', tx_symbol_diff, '0']
- [tx_symbol_diff, '0', tx_symbols, '0']
- [tx_symbols, '0', tx_constellation, '0']
- [eye_input, '0', eye_i, '0']
- [eye_i, '0', eye, '0']
- [eye_q, '0', eye_quadrature, '0']
- [ideal_symbols, '0', ideal_symbols_link, '0']
- [evm_circles, '0', evm_circles_link, '0']
- [tx_dbm, '0', tx_dbm_link, '0']
- [constellation_reference_1, '0', constellation, '1']
- [constellation_reference_2, '0', constellation, '2']
- [tx_constellation_reference_1, '0', tx_constellation, '1']
- [tx_constellation_reference_2, '0', tx_constellation, '2']
- [rx_snr_input, '0', rx_snr, '0']
- [rx_ebno_input, '0', rx_ebno, '0']
- [eye_q_input, '0', eye_q, '0']
- [rx_scale, '0', equalizer, '0']
- [rx_scale, '0', pre_eq_link, '0']
- [before_eq_input, '0', before_eq_constellation, '0']
- [middle_input, '0', middle_eye_reconstruction, '0']
- [middle_eye_reconstruction, '0', middle_i, '0']
- [middle_i, '0', middle_i_eye, '0']
- [middle_eye_reconstruction, '0', middle_q, '0']
- [middle_q, '0', middle_q_eye, '0']
- [after_input, '0', after_eye_reconstruction, '0']
- [after_eye_reconstruction, '0', after_i, '0']
- [after_i, '0', after_i_eye, '0']
- [after_eye_reconstruction, '0', after_q, '0']
- [after_q, '0', after_q_eye, '0']
- [tx_eye_input, '0', tx_eye_i, '0']
- [tx_eye_i, '0', tx_eye_i_eye, '0']
- [tx_eye_input, '0', tx_eye_q, '0']
- [tx_eye_q, '0', tx_eye_q_eye, '0']
- [tx_wave_input, '0', tx_waveform, '0']
- [evm_meter_history_input, '0', eq_evm_history, '0']
- [eq_tap_decimator, '0', eq_tap_magnitudes, '0']
- [eq_tap_magnitudes, '0', eq_tap_plot, '0']
- [spectrum_budget_input, '0', spectrum_budget, '0']
- [rx_snr, '0', snr_history_link, '0']
- [power_reference_chart_input, '0', power_reference_chart, '0']
- [evm, '0', evm_per_symbol_link, '0']
- [eq_error_trace_input, '0', eq_error_trace, '0']
- [equalizer, '1', adaptive_tap_vectors_link, '0']
- [eq_tap_decimator_input, '0', eq_tap_decimator, '0']
- [tx_power, '0', usrp_tx, '0']
- [usrp_rx, '0', rx_level, '0']
- [usrp_rx, '0', rx_iq_link, '0']
- [clock_sync, '0', carrier_sync, '0']
- [carrier_sync, '0', rx_scale, '0']
- [equalizer, '0', phase_fix, '0']
- [unpack_rx, '0', delay, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
