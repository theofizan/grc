options:
  parameters:
    id: n210_8ask
    title: 8-ASK over the air | two USRP N210s
    generate_options: qt_gui
    output_language: python
    author: Antenna benchmark
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, alpha, 11*sps*nfilts)
  states: {}
- name: const
  id: variable_constellation_rect
  parameters:
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    const_points: '[-7, -5, -3, -1, 1, 3, 5, 7]'
    rot_sym: '1'
    real_sect: '8'
    imag_sect: '1'
    w_real_sect: '2'
    w_imag_sect: '1'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: warmup_bits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: k
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    value: 1e6
    type: eng_float
    label: Symbol rate (symbols/s)
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: symbol_rate*k
  states: {}
- name: rrc_bandwidth
  id: variable
  parameters:
    value: symbol_rate*(1+alpha)
  states: {}
- name: random_bytes
  id: blocks_vector_source_x
  parameters:
    type: byte
    vector: tx_data
    repeat: 'True'
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'False'
    samples_per_symbol: sps
    excess_bw: alpha
  states: {}
- name: clock_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '0.05'
    osps: '1'
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: decoded_link
  id: virtual_sink
  parameters:
    stream_id: decoded
  states: {}
- name: reference_link
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: decoded_source
  id: virtual_source
  parameters:
    stream_id: decoded
  states: {}
- name: unpack_rx
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits+2*data_period_bits+int(settle_s*bit_rate)
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    type: byte
    delay: data_period_bits
  states: {}
- name: skip_tx
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits+2*data_period_bits+int(settle_s*bit_rate)
  states: {}
- name: xor
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: errors_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: integrate
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: ber_window
  states: {}
- name: ber_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 0.5/ber_window
  states: {}
- name: ber_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: BER | RX vs RX one data period earlier, /2 (preamble-trained)
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    label1: Bit error ratio
    unit1: errors/bit
    gui_hint: views@0:0,0,1,1
    update_time: plot_update_s
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: After adaptive LMS equalization | symbols and guides
    size: '1024'
    nconnections: '3'
    grid: 'True'
    gui_hint: views@0:2,0,1,1
    label1: RX symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    color2: '"black"'
    color3: '"dark green"'
    marker2: '8'
    alpha1: '0.3'
    alpha3: '0.5'
    update_time: plot_update_s
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: TX and RX baseband spectrum | relative dB
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: samp_rate
    nconnections: '2'
    gui_hint: views@1:2,0,1,1
    label1: RX
    label2: TX
    update_time: plot_update_s
  states: {}
- name: waveform
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: TX and RX waveform | I/Q
    size: '512'
    srate: samp_rate
    nconnections: '2'
    gui_hint: views@1:1,1,1,1
    label1: RX I
    label2: RX Q
    label3: TX I
    label4: TX Q
    update_time: plot_update_s
  states: {}
- name: evm
  id: digital_meas_evm_cc
  parameters:
    cons: const
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: evm_rms
  id: blocks_rms_xx
  parameters:
    type: float
    alpha: '0.001'
  states: {}
- name: evm_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: Decision-directed RMS EVM
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    max: '100'
    label1: Decision-directed EVM
    unit1: '%'
    gui_hint: views@0:0,1,1,1
    update_time: plot_update_s
  states: {}
- name: scope
  id: note
  parameters:
    note: 'SISO single carrier, RRC pulse shaping. 8ASK, 4 samples/symbol. No carrier recovery: leave frequency offset=0 and epsilon=1 for scored BER. Delay calibrated for this filter/clock configuration. See README.md.'
  states: {}
- name: rx_iq_link
  id: virtual_sink
  parameters:
    stream_id: rx_iq
  states: {}
- name: symbols_link
  id: virtual_sink
  parameters:
    stream_id: rx_symbols
  states: {}
- name: symbols_plot
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: spectrum_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: waveform_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: evm_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: symbol_rms
  id: variable
  parameters:
    value: (sum(abs(p)**2 for p in const.points())/len(const.points()))**0.5
  states: {}
- name: tx_power
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_amplitude/symbol_rms
  states: {}
- name: rx_scale
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    num_tabs: '6'
    label0: Constellations
    label1: Waveforms
    label2: I eyes
    label3: RF levels
    label4: Q eyes
    label5: BER / EVM / taps
  states: {}
- name: tx_plot_link
  id: virtual_sink
  parameters:
    stream_id: tx_iq
  states: {}
- name: timing_link
  id: virtual_sink
  parameters:
    stream_id: timing_error
  states: {}
- name: ber_link
  id: virtual_sink
  parameters:
    stream_id: ber_history
  states: {}
- name: evm_link
  id: virtual_sink
  parameters:
    stream_id: evm_history
  states: {}
- name: tx_spectrum
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_time
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: ber_plot_input
  id: virtual_source
  parameters:
    stream_id: ber_history
  states: {}
- name: ber_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: BER per window (preamble-trained, RX vs RX one period earlier)
    size: '128'
    srate: bit_rate/ber_window
    autoscale: 'True'
    gui_hint: views@5:1,0,1,1
    ylabel: Bit error ratio
    yunit: ''
    label1: BER
    ymin: '0'
    update_time: plot_update_s
  states: {}
- name: evm_plot_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: evm_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Smoothed decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@5:1,1,1,1
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
    update_time: plot_update_s
  states: {}
- name: timing_input
  id: virtual_source
  parameters:
    stream_id: timing_error
  states: {}
- name: timing_error
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Clock sync timing error
    size: '512'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@1:2,1,1,1
    update_time: plot_update_s
  states: {}
- name: eye_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: views@2:1,1,1,1
    ylabel: RX in-phase amplitude
    label1: RX I | raw N210 RX output
    update_time: plot_update_s
  states: {}
- name: unused_timing_states
  id: blocks_null_sink
  parameters:
    type: float
    num_inputs: '2'
  states: {}
- name: tx_level_dbfs
  id: variable_qtgui_range
  parameters:
    value: '-15'
    start: '-40'
    stop: '0'
    step: '0.5'
    label: TX digital level (dBFS RMS, keep peak < 0)
    gui_hint: views@3:3,0,1,2
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    value: 10**(tx_level_dbfs/20.0)
  states: {}
- name: rx_level
  id: analog_agc2_xx
  parameters:
    type: complex
    attack_rate: '1e-3'
    decay_rate: '1e-3'
    reference: '1.0'
    gain: '1.0'
    max_gain: '65536'
  states: {}
- name: tx_meter_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: tx_power_sum
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '4096'
  states: {}
- name: tx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 1.0/4096
  states: {}
- name: tx_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: rx_meter_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: rx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_power_sum
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '4096'
  states: {}
- name: rx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: 1.0/4096
  states: {}
- name: rx_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: tx_peak_vectors
  id: blocks_stream_to_vector
  parameters:
    type: float
    num_items: '4096'
  states: {}
- name: tx_peak_mw
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '4096'
    vlen_out: '1'
  states: {}
- name: tx_peak_dbm
  id: blocks_nlog10_ff
  parameters:
    n: '10'
    k: '0'
  states: {}
- name: tx_mw_link
  id: virtual_sink
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: peak_input
  id: virtual_source
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: chart_math
  id: import
  parameters:
    imports: |-
      import math
      import numpy
  states: {}
- name: evm_guide_percent
  id: parameter
  parameters:
    value: '5'
    type: eng_float
    label: Constellation guide radius (% RMS)
  states: {}
- name: rx_snr
  id: blocks_nlog10_ff
  parameters:
    n: '-20'
    k: '40'
  states: {}
- name: rx_ebno
  id: blocks_nlog10_ff
  parameters:
    n: '-20'
    k: 40-10*math.log10(k)
  states: {}
- name: tx_symbol_input
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: tx_symbol_chunks
  id: blocks_packed_to_unpacked_xx
  parameters:
    type: byte
    bits_per_chunk: k
    endianness: gr.GR_MSB_FIRST
  states: {}
- name: tx_symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: const.points()
    dimension: '1'
  states: {}
- name: tx_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: 'TX before RRC: blue symbols / black ideal / green guide'
    size: '1024'
    nconnections: '3'
    grid: 'True'
    gui_hint: views@0:1,0,1,1
    label1: TX encoded symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    color2: '"black"'
    color3: '"dark green"'
    marker2: '8'
    alpha1: '0.3'
    alpha3: '0.5'
    update_time: plot_update_s
  states: {}
- name: ideal_symbols
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: const.points()
    repeat: 'True'
  states: {}
- name: evm_circles
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: '[p+symbol_rms*evm_guide_percent/100*complex(math.cos(t),math.sin(t)) for p in const.points() for t in numpy.linspace(0,2*math.pi,64,endpoint=False)]'
    repeat: 'True'
  states: {}
- name: eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: eye_quadrature
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    gui_hint: views@4:1,1,1,1
    ylabel: RX quadrature amplitude
    label1: RX Q | raw N210 RX output
    update_time: plot_update_s
  states: {}
- name: square_plot_panels
  id: snippet
  parameters:
    section: main_after_init
    code: |
      # Plot layout is a resizable 2x2 grid, not a square-canvas constraint.
      for index in range(self.views.count()):
          layout = getattr(self, "views_grid_layout_"+str(index))
          if layout is not None:
              layout.setColumnStretch(0, 1)
              layout.setColumnStretch(1, 1)
              layout.setRowStretch(1, 1)
              layout.setRowStretch(2, 1)
              # Native sinks otherwise request a large minimum and force scrolling.
              for row in (1, 2):
                  for column in (0, 1):
                      panel = layout.itemAtPosition(row, column).widget()
                      panel.setMinimumSize(0, 0)
                      panel.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.views.setMinimumSize(0, 0)
      self.views.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.resize(1180, 900)
    comment: 'UI layout only: resizable 2x2 dashboards.'
  states: {}
- name: ideal_symbols_link
  id: virtual_sink
  parameters:
    stream_id: ideal_points
  states: {}
- name: evm_circles_link
  id: virtual_sink
  parameters:
    stream_id: guide_circles
  states: {}
- name: tx_dbm_link
  id: virtual_sink
  parameters:
    stream_id: sensed_tx_dbm
  states: {}
- name: constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: tx_constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: tx_constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: rx_snr_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: eye_q_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eq_taps
  id: parameter
  parameters:
    value: '11'
    type: intx
    label: Adaptive equalizer taps
  states: {}
- name: eq_step
  id: parameter
  parameters:
    value: '0.01'
    type: eng_float
    label: NLMS adaptation step
  states: {}
- name: eq_algorithm
  id: variable_adaptive_algorithm
  parameters:
    type: lms
    cons: const
    step_size: eq_step/(eq_taps*symbol_rms**2)
  states: {}
- name: equalizer
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: training_symbols[:eq_training_len]
  states: {}
- name: pre_eq_link
  id: virtual_sink
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: before_eq_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: before_eq_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: 'Middle: timed symbols before adaptive EQ'
    size: '1024'
    grid: 'True'
    gui_hint: views@0:1,1,1,1
    update_time: plot_update_s
  states: {}
- name: eye_synthesis_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps,sps,1.0,alpha,11*sps)
  states: {}
- name: middle_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: middle_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: eye_synthesis_taps
  states: {}
- name: middle_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: middle_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: MIDDLE I | reconstructed
    gui_hint: views@2:2,0,1,1
    label1: Middle I | before EQ, reconstructed
    update_time: plot_update_s
  states: {}
- name: middle_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: middle_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: MIDDLE Q | reconstructed
    gui_hint: views@4:2,0,1,1
    label1: Middle Q | before EQ, reconstructed
    update_time: plot_update_s
  states: {}
- name: after_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: after_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    type: ccf
    interp: sps
    taps: eye_synthesis_taps
  states: {}
- name: after_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: after_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: AFTER I | reconstructed
    gui_hint: views@2:2,1,1,1
    label1: After EQ I | reconstructed
    update_time: plot_update_s
  states: {}
- name: after_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: after_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: AFTER Q | reconstructed
    gui_hint: views@4:2,1,1,1
    label1: After EQ Q | reconstructed
    update_time: plot_update_s
  states: {}
- name: tx_eye_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: tx_eye_i_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: TX_EYE I | TX shaped
    gui_hint: views@2:1,0,1,1
    label1: TX I | shaped waveform
    update_time: plot_update_s
  states: {}
- name: tx_eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: tx_eye_q_eye
  id: qtgui_eye_sink_x
  parameters:
    type: float
    size: '1024'
    samp_per_symbol: sps
    srate: samp_rate
    grid: 'True'
    autoscale: 'True'
    ylabel: TX_EYE Q | TX shaped
    gui_hint: views@4:1,0,1,1
    label1: TX Q | shaped waveform
    update_time: plot_update_s
  states: {}
- name: tx_wave_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_waveform
  id: qtgui_time_sink_x
  parameters:
    type: complex
    name: Clean TX waveform | I/Q
    size: '512'
    srate: samp_rate
    gui_hint: views@1:1,0,1,1
    update_time: plot_update_s
  states: {}
- name: evm_meter_history_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: eq_evm_history
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Equalized decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    gui_hint: views@0:2,1,1,1
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
    update_time: plot_update_s
  states: {}
- name: spectrum_budget
  id: qtgui_freq_sink_x
  parameters:
    type: complex
    name: RX spectrum | relative level
    gui_hint: views@3:1,1,1,1
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: samp_rate
    label1: RX
    update_time: plot_update_s
  states: {}
- name: eq_error_trace
  id: qtgui_time_sink_x
  parameters:
    type: float
    name: Per-symbol equalized EVM (%)
    gui_hint: views@5:2,0,1,1
    size: '128'
    srate: symbol_rate
    autoscale: 'True'
    ylabel: EVM
    yunit: '%'
    label1: Decision-directed EVM
    update_time: plot_update_s
  states: {}
- name: equalizer_initial_taps
  id: snippet
  parameters:
    section: main_after_init
    code: self.equalizer.set_taps([0j]*((self.eq_taps-1)//2)+[1+0j]+[0j]*(self.eq_taps//2))
  states: {}
- name: eq_delay_symbols
  id: variable
  parameters:
    value: (eq_taps-1)//2
  states: {}
- name: eq_tap_decimator
  id: blocks_keep_one_in_n
  parameters:
    type: complex
    vlen: eq_taps
    n: '1000'
  states: {}
- name: eq_tap_magnitudes
  id: blocks_complex_to_mag
  parameters:
    vlen: eq_taps
  states: {}
- name: eq_tap_plot
  id: qtgui_vector_sink_f
  parameters:
    name: Adaptive LMS tap magnitudes | updated during convergence
    vlen: eq_taps
    x_start: '0'
    x_step: '1'
    x_axis_label: Tap index
    y_axis_label: Magnitude
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@5:2,1,1,1
    update_time: plot_update_s
  states: {}
- name: spectrum_budget_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: evm_per_symbol_link
  id: virtual_sink
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: eq_error_trace_input
  id: virtual_source
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: adaptive_tap_vectors_link
  id: virtual_sink
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: eq_tap_decimator_input
  id: virtual_source
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: section_controls
  id: note
  parameters:
    note: CONTROLS & RF SETTINGS
  states: {}
- name: section_transmitter
  id: note
  parameters:
    note: TRANSMITTER
  states: {}
- name: section_channel
  id: note
  parameters:
    note: N210 RF FRONT END
  states: {}
- name: section_receiver
  id: note
  parameters:
    note: RECEIVER
  states: {}
- name: section_ber
  id: note
  parameters:
    note: BER MEASUREMENT
  states: {}
- name: section_rx_diagnostics
  id: note
  parameters:
    note: RX DIAGNOSTICS
  states: {}
- name: section_power
  id: note
  parameters:
    note: LINK BUDGET & POWER METERS
  states: {}
- name: section_reference
  id: note
  parameters:
    note: TX SYMBOL REFERENCE & EVM GUIDES
  states: {}
- name: section_pre_eq
  id: note
  parameters:
    note: BEFORE EQUALIZATION
  states: {}
- name: section_eyes
  id: note
  parameters:
    note: 'EYE COMPARISON: MIDDLE / AFTER EQ / TX'
  states: {}
- name: section_extra_plots
  id: note
  parameters:
    note: LIVE WAVEFORM & ADAPTATION MONITORS
  states: {}
- name: tx_papr
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: plot_update_s
  id: parameter
  parameters:
    value: '0.5'
    type: eng_float
    label: Plot refresh interval (s)
  states: {}
- name: section_ber_test
  id: note
  parameters:
    note: BER TEST (FIXED LENGTH)
  states: {}
- name: ber_test_bits
  id: parameter
  parameters:
    value: '1000000'
    type: intx
    label: BER test length (compared bits)
  states: {}
- name: ber_test_blocks
  id: variable
  parameters:
    value: max(1, int(ber_test_bits) // 10000)
  states: {}
- name: ber_test_start
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ber_error_weight
  id: variable
  parameters:
    value: '0.5'
  states: {}
- name: ber_test_seconds
  id: variable
  parameters:
    value: (warmup_bits + 3*data_period_bits + 10000*ber_test_blocks) / bit_rate + settle_s
  states: {}
- name: bit_errors_link
  id: virtual_sink
  parameters:
    stream_id: bit_errors
  states: {}
- name: bit_errors_to_ber_test
  id: virtual_source
  parameters:
    stream_id: bit_errors
  states: {}
- name: ber_test_sum_10k
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '10000'
  states: {}
- name: ber_test_zero
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '0'
  states: {}
- name: ber_test_unit
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1'
  states: {}
- name: ber_test_index
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_started
  id: blocks_threshold_ff
  parameters:
    low: ber_test_start + 0.5
    high: ber_test_start + 0.5
    init: '0'
  states: {}
- name: ber_test_done
  id: blocks_threshold_ff
  parameters:
    low: ber_test_start + ber_test_blocks + 0.5
    high: ber_test_start + ber_test_blocks + 0.5
    init: '0'
  states: {}
- name: ber_test_gate
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: ber_test_gated_errors
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: ber_test_error_sum
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_errors
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: ber_error_weight
  states: {}
- name: ber_test_window_sum
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_count
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '10000'
  states: {}
- name: ber_test_ratio
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: tx_usrp_address
  id: parameter
  parameters:
    value: addr=192.168.10.2
    type: str
    label: TX N210 device address
  states: {}
- name: rx_usrp_address
  id: parameter
  parameters:
    value: addr=192.168.10.2
    type: str
    label: RX N210 device address (same as TX for loopback)
  states: {}
- name: center_freq_hz
  id: parameter
  parameters:
    value: 915e6
    type: eng_float
    label: RF center frequency (Hz)
  states: {}
- name: tx_gain_db
  id: variable_qtgui_range
  parameters:
    value: '10'
    start: '0'
    stop: '31.5'
    step: '0.5'
    label: TX gain (dB)
    gui_hint: views@3:0,0,1,1
  states: {}
- name: rx_gain_db
  id: variable_qtgui_range
  parameters:
    value: '10'
    start: '0'
    stop: '31.5'
    step: '0.5'
    label: RX gain (dB)
    gui_hint: views@3:0,1,1,1
  states: {}
- name: carrier_loop_bw
  id: variable
  parameters:
    value: 2*math.pi/800
  states: {}
- name: data_period_bits
  id: variable
  parameters:
    value: 8*len(tx_data)
  states: {}
- name: settle_s
  id: parameter
  parameters:
    value: '1.0'
    type: eng_float
    label: Settling time before BER counting (s)
  states: {}
- name: tx_data
  id: variable
  parameters:
    value: numpy.random.RandomState(42).randint(0, 256, 32766).astype(numpy.uint8)
  states: {}
- name: training_symbols
  id: variable
  parameters:
    value: numpy.asarray(const.points())[numpy.packbits(numpy.hstack([numpy.zeros((data_period_bits // k, 8-k), dtype=numpy.uint8), numpy.unpackbits(numpy.array(tx_data, dtype=numpy.uint8)).reshape(-1, k)]), axis=1).ravel()]
  states: {}
- name: preamble_len
  id: variable
  parameters:
    value: '128'
  states: {}
- name: eq_training_len
  id: variable
  parameters:
    value: len(training_symbols)
  states: {}
- name: usrp_tx
  id: uhd_usrp_sink
  parameters:
    type: fc32
    otw: sc16
    dev_addr: tx_usrp_address
    dev_args: '"num_send_frames=512,num_recv_frames=512"'
    sync: none
    samp_rate: samp_rate
    center_freq0: center_freq_hz
    gain0: tx_gain_db
    ant0: '"TX/RX"'
  states: {}
- name: usrp_rx
  id: uhd_usrp_source
  parameters:
    type: fc32
    otw: sc16
    dev_addr: rx_usrp_address
    dev_args: '"num_send_frames=512,num_recv_frames=512"'
    sync: none
    samp_rate: samp_rate
    center_freq0: center_freq_hz
    rx_agc0: Disabled
    gain0: rx_gain_db
    ant0: '"RX2"'
    dc_offs_enb0: auto
    iq_imbal_enb0: auto
  states: {}
- name: rx_limit_split
  id: blocks_complex_to_float
  parameters: {}
  states: {}
- name: rx_limit_i
  id: analog_rail_ff
  parameters:
    lo: '-3'
    hi: '3'
  states: {}
- name: rx_limit_q
  id: analog_rail_ff
  parameters:
    lo: '-3'
    hi: '3'
  states: {}
- name: rx_limit_join
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: preamble_detect
  id: digital_corr_est_cc
  parameters:
    symbols: list(numpy.array(training_symbols[:preamble_len])/symbol_rms)
    sps: '1'
    mark_delay: eq_delay_symbols+1
    threshold: '0.9999'
    threshold_method: digital.THRESHOLD_DYNAMIC
  states: {}
- name: carrier_sync
  id: digital_costas_loop_cc
  parameters:
    w: carrier_loop_bw
    order: '2'
  states: {}
- name: evm_table_rate
  id: blocks_keep_one_in_n
  parameters:
    type: float
    n: 4096//sps
  states: {}
- name: probe_tx_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_tx_peak_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_tx_papr
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_snr
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_ebno
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_evm_rms
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_scale
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_count
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_errors
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_ratio
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_index
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: link_table
  id: snippet
  parameters:
    section: main_after_init
    priority: '1'
    code: |
      # Link budget and BER test as a spreadsheet-style table (display only).
      # Values come from stock Probe Signal blocks; edit rows here to change it.
      rows = [
          ('Transmit', 'Average level', self.probe_tx_dbm, 'dBFS', 'dB'),
          ('', 'Sampled peak (keep < 0)', self.probe_tx_peak_dbm, 'dBFS', 'dB'),
          ('', 'Peak / average', self.probe_tx_papr, 'dB', 'dB'),
          ('Receive', 'ADC level, fixed RF gain', self.probe_rx_dbm, 'dBFS', 'dB'),
          ('', 'MER (decision-directed)', self.probe_rx_snr, 'dB', 'dB'),
          ('', 'Eb/N0 estimate', self.probe_rx_ebno, 'dB', 'dB'),
          ('', 'EVM (decision-directed)', self.probe_evm_rms, '%', 'dB'),
          ('BER', 'Latest 10,000 bits', self.probe_ber_scale, 'errors/bit', 'ber'),
          ('BER test', 'Test length', None, 'bits', "f'{10000 * self.ber_test_blocks:,}'"),
          ('', 'Estimated time', None, 's', "f'{self.ber_test_seconds:.2f}'"),
          ('', 'Status', self.probe_ber_test_count, '', 'status'),
          ('', 'Bits compared', self.probe_ber_test_count, 'bits', 'test_count'),
          ('', 'Bit errors (mismatches / 2)', self.probe_ber_test_errors, 'errors', 'test_errors'),
          ('', 'BER', self.probe_ber_test_ratio, 'errors/bit', 'test_ber'),
      ]
      table = Qt.QTableWidget(len(rows), 4)
      table.setHorizontalHeaderLabels(["Section", "Quantity", "Value", "Unit"])
      table.verticalHeader().setVisible(False)
      table.setEditTriggers(Qt.QAbstractItemView.NoEditTriggers)
      table.setSelectionMode(Qt.QAbstractItemView.NoSelection)
      table.setAlternatingRowColors(True)
      table.setShowGrid(True)
      bold = Qt.QFont(table.font())
      bold.setBold(True)
      for row, (section, quantity, probe, unit, fmt) in enumerate(rows):
          for column, text in ((0, section), (1, quantity), (3, unit)):
              item = Qt.QTableWidgetItem(text)
              if column == 0:
                  item.setFont(bold)
              table.setItem(row, column, item)
          value = Qt.QTableWidgetItem("" if probe else str(eval(fmt)))
          value.setTextAlignment(Qt.Qt.AlignRight | Qt.Qt.AlignVCenter)
          table.setItem(row, 2, value)
      header = table.horizontalHeader()
      header.setSectionResizeMode(Qt.QHeaderView.ResizeToContents)
      header.setStretchLastSection(True)
      test_bits = 10000 * self.ber_test_blocks
      # BER test totals run since the flowchart started; each test is shown relative
      # to the totals frozen when it began (zero for the first test).
      test = dict(base_count=0.0, base_errors=0.0, restarting=False)

      def test_values():
          count = self.probe_ber_test_count.level() - test["base_count"]
          errors = self.probe_ber_test_errors.level() - test["base_errors"]
          return count, errors

      def refresh_link_table():
          count, errors = test_values()
          for row, (section, quantity, probe, unit, fmt) in enumerate(rows):
              if probe is None:
                  continue
              level = probe.level()
              if fmt == "dB":
                  text = f"{level:.2f}"
              elif fmt == "count":
                  text = f"{level:,.0f}"
              elif fmt == "ber":
                  text = f"{level:.3e}"
              elif fmt == "test_count":
                  text = f"{count:,.0f}"
              elif fmt == "test_errors":
                  text = f"{errors:,.0f}"
              elif fmt == "test_ber":
                  text = f"{errors / count:.3e}" if count > 0 else ""
              elif test["restarting"]:
                  text = "restarting"
              else:
                  text = "complete" if count >= test_bits else (
                      "counting" if count > 0 else "waiting for warm-up")
              table.item(row, 2).setText(text)

      def restart_ber_test():
          # 1) Close the test gate so the running totals freeze.
          test["restarting"] = True
          self.set_ber_test_start(1e15)
          Qt.QTimer.singleShot(500, begin_new_test)

      def begin_new_test():
          # 2) Frozen totals become the new zero; the new test starts a quarter
          #    second ahead, so every counted 10,000-bit window is new and the test
          #    covers exactly ber_test_bits bits.
          test["base_count"] = self.probe_ber_test_count.level()
          test["base_errors"] = self.probe_ber_test_errors.level()
          ahead = max(2, int(0.25 * self.bit_rate / 10000))
          self.set_ber_test_start(self.probe_ber_test_index.level() + ahead)
          test["restarting"] = False

      self.restart_ber_test = restart_ber_test
      self.restart_ber_test_button = Qt.QPushButton("Restart BER test")
      self.restart_ber_test_button.clicked.connect(restart_ber_test)
      self.views_grid_layout_3.addWidget(self.restart_ber_test_button, 4, 0, 1, 2)

      self.link_table = table
      self.link_table_timer = Qt.QTimer()
      self.link_table_timer.timeout.connect(refresh_link_table)
      self.link_table_timer.start(int(1000 * self.plot_update_s))
      self.views_grid_layout_3.addWidget(table, 1, 0, 2, 1)
  states: {}
- name: rf_constellation_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: rf_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: Received symbols (after equalizer)
    size: '1024'
    grid: 'True'
    gui_hint: views@3:2,1,1,1
    label1: RX
    alpha1: '0.4'
    update_time: plot_update_s
    legend: 'False'
  states: {}

connections:
- [random_bytes, '0', modulator, '0']
- [modulator, '0', tx_power, '0']
- [equalizer, '0', decoder, '0']
- [decoder, '0', decoded_link, '0']
- [random_bytes, '0', reference_link, '0']
- [unpack_rx, '0', skip_rx, '0']
- [delay, '0', skip_tx, '0']
- [skip_rx, '0', xor, '0']
- [xor, '0', errors_float, '0']
- [errors_float, '0', integrate, '0']
- [integrate, '0', ber_scale, '0']
- [ber_scale, '0', ber_display, '0']
- [skip_tx, '0', xor, '1']
- [evm, '0', evm_rms, '0']
- [evm_rms, '0', evm_display, '0']
- [equalizer, '0', symbols_link, '0']
- [symbols_plot, '0', constellation, '0']
- [spectrum_input, '0', spectrum, '0']
- [waveform_input, '0', waveform, '0']
- [evm_input, '0', evm, '0']
- [tx_power, '0', tx_plot_link, '0']
- [clock_sync, '1', timing_link, '0']
- [ber_scale, '0', ber_link, '0']
- [evm_rms, '0', evm_link, '0']
- [tx_spectrum, '0', spectrum, '1']
- [tx_time, '0', waveform, '1']
- [ber_plot_input, '0', ber_history, '0']
- [evm_plot_input, '0', evm_history, '0']
- [timing_input, '0', timing_error, '0']
- [clock_sync, '2', unused_timing_states, '0']
- [clock_sync, '3', unused_timing_states, '1']
- [tx_meter_input, '0', tx_milliwatts, '0']
- [tx_milliwatts, '0', tx_power_sum, '0']
- [tx_power_sum, '0', tx_power_mean, '0']
- [tx_power_mean, '0', tx_dbm, '0']
- [rx_meter_input, '0', rx_milliwatts, '0']
- [rx_milliwatts, '0', rx_power_sum, '0']
- [rx_power_sum, '0', rx_power_mean, '0']
- [rx_power_mean, '0', rx_dbm, '0']
- [tx_peak_vectors, '0', tx_peak_mw, '0']
- [tx_peak_mw, '0', tx_peak_dbm, '0']
- [tx_milliwatts, '0', tx_mw_link, '0']
- [peak_input, '0', tx_peak_vectors, '0']
- [tx_symbol_input, '0', tx_symbol_chunks, '0']
- [tx_symbols, '0', tx_constellation, '0']
- [eye_input, '0', eye_i, '0']
- [eye_i, '0', eye, '0']
- [eye_q, '0', eye_quadrature, '0']
- [ideal_symbols, '0', ideal_symbols_link, '0']
- [evm_circles, '0', evm_circles_link, '0']
- [tx_dbm, '0', tx_dbm_link, '0']
- [constellation_reference_1, '0', constellation, '1']
- [constellation_reference_2, '0', constellation, '2']
- [tx_constellation_reference_1, '0', tx_constellation, '1']
- [tx_constellation_reference_2, '0', tx_constellation, '2']
- [eye_q_input, '0', eye_q, '0']
- [rx_scale, '0', equalizer, '0']
- [rx_scale, '0', pre_eq_link, '0']
- [before_eq_input, '0', before_eq_constellation, '0']
- [middle_input, '0', middle_eye_reconstruction, '0']
- [middle_eye_reconstruction, '0', middle_i, '0']
- [middle_i, '0', middle_i_eye, '0']
- [middle_eye_reconstruction, '0', middle_q, '0']
- [middle_q, '0', middle_q_eye, '0']
- [after_input, '0', after_eye_reconstruction, '0']
- [after_eye_reconstruction, '0', after_i, '0']
- [after_i, '0', after_i_eye, '0']
- [after_eye_reconstruction, '0', after_q, '0']
- [after_q, '0', after_q_eye, '0']
- [tx_eye_input, '0', tx_eye_i, '0']
- [tx_eye_i, '0', tx_eye_i_eye, '0']
- [tx_eye_input, '0', tx_eye_q, '0']
- [tx_eye_q, '0', tx_eye_q_eye, '0']
- [tx_wave_input, '0', tx_waveform, '0']
- [evm_meter_history_input, '0', eq_evm_history, '0']
- [eq_tap_decimator, '0', eq_tap_magnitudes, '0']
- [eq_tap_magnitudes, '0', eq_tap_plot, '0']
- [spectrum_budget_input, '0', spectrum_budget, '0']
- [evm, '0', evm_per_symbol_link, '0']
- [eq_error_trace_input, '0', eq_error_trace, '0']
- [equalizer, '1', adaptive_tap_vectors_link, '0']
- [eq_tap_decimator_input, '0', eq_tap_decimator, '0']
- [tx_peak_dbm, '0', tx_papr, '0']
- [tx_dbm, '0', tx_papr, '1']
- [errors_float, '0', bit_errors_link, '0']
- [bit_errors_to_ber_test, '0', ber_test_sum_10k, '0']
- [ber_test_sum_10k, '0', ber_test_zero, '0']
- [ber_test_zero, '0', ber_test_unit, '0']
- [ber_test_unit, '0', ber_test_index, '0']
- [ber_test_index, '0', ber_test_started, '0']
- [ber_test_index, '0', ber_test_done, '0']
- [ber_test_started, '0', ber_test_gate, '0']
- [ber_test_done, '0', ber_test_gate, '1']
- [ber_test_sum_10k, '0', ber_test_gated_errors, '0']
- [ber_test_gate, '0', ber_test_gated_errors, '1']
- [ber_test_gated_errors, '0', ber_test_error_sum, '0']
- [ber_test_error_sum, '0', ber_test_errors, '0']
- [ber_test_gate, '0', ber_test_window_sum, '0']
- [ber_test_window_sum, '0', ber_test_count, '0']
- [ber_test_errors, '0', ber_test_ratio, '0']
- [ber_test_count, '0', ber_test_ratio, '1']
- [tx_power, '0', usrp_tx, '0']
- [usrp_rx, '0', rx_level, '0']
- [usrp_rx, '0', rx_iq_link, '0']
- [rx_level, '0', rx_limit_split, '0']
- [rx_limit_split, '0', rx_limit_i, '0']
- [rx_limit_split, '1', rx_limit_q, '0']
- [rx_limit_i, '0', rx_limit_join, '0']
- [rx_limit_q, '0', rx_limit_join, '1']
- [rx_limit_join, '0', clock_sync, '0']
- [clock_sync, '0', carrier_sync, '0']
- [carrier_sync, '0', preamble_detect, '0']
- [preamble_detect, '0', rx_scale, '0']
- [decoded_source, '0', unpack_rx, '0']
- [tx_symbol_chunks, '0', tx_symbols, '0']
- [unpack_rx, '0', delay, '0']
- [rx_snr_input, '0', evm_table_rate, '0']
- [evm_table_rate, '0', rx_snr, '0']
- [evm_table_rate, '0', rx_ebno, '0']
- [tx_dbm, '0', probe_tx_dbm, '0']
- [tx_peak_dbm, '0', probe_tx_peak_dbm, '0']
- [tx_papr, '0', probe_tx_papr, '0']
- [rx_dbm, '0', probe_rx_dbm, '0']
- [rx_snr, '0', probe_rx_snr, '0']
- [rx_ebno, '0', probe_rx_ebno, '0']
- [evm_rms, '0', probe_evm_rms, '0']
- [ber_scale, '0', probe_ber_scale, '0']
- [ber_test_count, '0', probe_ber_test_count, '0']
- [ber_test_errors, '0', probe_ber_test_errors, '0']
- [ber_test_ratio, '0', probe_ber_test_ratio, '0']
- [ber_test_index, '0', probe_ber_test_index, '0']
- [rf_constellation_input, '0', rf_constellation, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
