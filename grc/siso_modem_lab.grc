options:
  parameters:
    author: Antenna benchmark project
    description: Complete uncoded symbol-rate SISO chain, ideal scalar receiver, live BER/EVM and Qt plots.
    generate_options: qt_gui
    id: siso_modem_lab
    output_language: python
    run_options: run
    title: 'SISO modem: bits -> modulation -> channel -> decisions -> BER/EVM'
  states: {}

blocks:
- name: channel_gain
  id: variable
  parameters:
    value: 10**(-path_loss_db/20)
  states: {}
- name: constellation_object
  id: variable
  parameters:
    value: digital.constellation_calcdist(wlan_constellation(order).tolist(),list(range(order)),1,1,digital.constellation.NO_NORMALIZATION).base()
  states: {}
- name: k
  id: variable
  parameters:
    value: int(math.log2(order))
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: math.sqrt(1/(k*10**(ebno_db/10)))
  states: {}
- name: awgn
  id: analog_noise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    seed: '20261017'
    type: complex
  states: {}
- name: ber_display
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: views@0:0,0,1,1
    label1: Cumulative pre-FEC BER
    min: '0'
    name: Cumulative pre-FEC BER
    type: float
    unit1: errors/bit
  states: {}
- name: ber_meter
  id: epy_block
  parameters:
    _source_code: |
      import antenna_bench.gr_metrics as metrics

      class blk(metrics.BitErrorMeter):
          def __init__(self, report_path="", run_config=None):
              super().__init__(report_path, run_config)
    report_path: str(ROOT / 'results/live/siso_modem_ber.json')
    run_config: dict(model='SISO symbol-rate',order=order,ebno_db=ebno_db,path_loss_db=path_loss_db)
  states: {}
- name: channel_output
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.5'
    grid: 'True'
    gui_hint: views@0:1,0,1,2
    label1: RX equalized DATA
    label2: TX reference DATA
    marker2: '8'
    name: SISO equalized symbols and known reference
    nconnections: '2'
    size: '1024'
    type: complex
    xmax: '2.0'
    xmin: '-2.0'
    ymax: '2.0'
    ymin: '-2.0'
  states: {}
- name: demap
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_object
  states: {}
- name: ebno_db
  id: parameter
  parameters:
    label: TX-reference uncoded Eb/N0 (dB)
    type: eng_float
    value: '20'
  states: {}
- name: equalize
  id: blocks_multiply_const_vxx
  parameters:
    const: 1/channel_gain
    type: complex
  states: {}
- name: evm_display
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: views@0:0,1,1,1
    label1: Pooled RMS EVM
    max: '100'
    min: '0'
    name: Pooled RMS EVM
    type: float
    unit1: '%'
  states: {}
- name: evm_meter
  id: epy_block
  parameters:
    _source_code: |
      import antenna_bench.gr_metrics as metrics

      class blk(metrics.EvmMeter):
          def __init__(self, report_path="", run_config=None):
              super().__init__(report_path, run_config)
    report_path: str(ROOT / 'results/live/siso_modem_evm.json')
    run_config: dict(model='SISO symbol-rate',order=order,ebno_db=ebno_db,path_loss_db=path_loss_db)
  states: {}
- name: finite_bits
  id: blocks_head
  parameters:
    num_items: symbol_count*k if symbol_count>0 else 2**60
    type: byte
  states: {}
- name: known_bits
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: test_bits(order).tolist()
  states: {}
- name: mapper
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: wlan_constellation(order).tolist()
  states: {}
- name: order
  id: parameter
  parameters:
    label: Constellation order M
    type: intx
    value: '16'
  states: {}
- name: pace
  id: parameter
  parameters:
    label: Playback samples per wall-clock second
    type: eng_float
    value: '200000'
  states: {}
- name: pace_tx
  id: blocks_throttle2
  parameters:
    samples_per_second: pace
    type: complex
  states: {}
- name: pack_bits
  id: blocks_pack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: path_loss_db
  id: parameter
  parameters:
    label: SISO power loss (dB)
    type: eng_float
    value: '0'
  states: {}
- name: power
  id: note
  parameters:
    note: Fixed TX Es=1; path loss reduces received SNR. AWGN is fixed relative to TX Eb/N0; it does NOT follow path loss.
  states: {}
- name: project_imports
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from antenna_bench.paths import ROOT
      from antenna_bench.live import test_bits, wlan_reference, burst_waveform, reference_symbols, parse_taps
      from antenna_bench.wlan import wlan_constellation
      from gnuradio import digital
  states: {}
- name: rx_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: rx_scope
  id: qtgui_sink_x
  parameters:
    bw: pace
    fc: '0'
    fftsize: '1024'
    gui_hint: views@2:0,0,1,2
    name: RX waveform | before equalization; relative FFT level
    plotconst: 'False'
    rate: '5'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: scope
  id: note
  parameters:
    note: 'SISO UNCODED SYMBOL LAB: 1 TX / 1 RX. Perfect timing, known scalar channel. Symbol-rate diagnostic, no RF pulse shaping.'
  states: {}
- name: siso_path
  id: blocks_multiply_const_vxx
  parameters:
    const: channel_gain
    type: complex
  states: {}
- name: symbol_count
  id: parameter
  parameters:
    label: Number of symbols
    type: intx
    value: '0'
  states: {}
- name: tx_scope
  id: qtgui_sink_x
  parameters:
    bw: pace
    fc: '0'
    fftsize: '1024'
    gui_hint: views@1:0,0,1,2
    name: TX waveform | complex baseband; relative FFT level
    plotconst: 'False'
    rate: '5'
    type: complex
    wintype: window.WIN_HANN
  states: {}
- name: use
  id: note
  parameters:
    note: symbol_count=0 runs until Stop (F7). Set >0 for finite checks. Stop writes exact BER counts / EVM JSON under results/live/.
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    label0: Metrics and constellation
    label1: 'TX waveform: spectrum / waterfall / time'
    label2: 'RX waveform: spectrum / waterfall / time'
    num_tabs: '3'
  states: {}

connections:
- [awgn, '0', channel_output, '1']
- [ber_meter, '0', ber_display, '0']
- [channel_output, '0', equalize, '0']
- [channel_output, '0', rx_scope, '0']
- [demap, '0', rx_bits, '0']
- [equalize, '0', constellation, '0']
- [equalize, '0', demap, '0']
- [equalize, '0', evm_meter, '1']
- [evm_meter, '0', evm_display, '0']
- [finite_bits, '0', ber_meter, '0']
- [finite_bits, '0', pack_bits, '0']
- [known_bits, '0', finite_bits, '0']
- [mapper, '0', constellation, '1']
- [mapper, '0', evm_meter, '0']
- [mapper, '0', pace_tx, '0']
- [pace_tx, '0', siso_path, '0']
- [pace_tx, '0', tx_scope, '0']
- [pack_bits, '0', mapper, '0']
- [rx_bits, '0', ber_meter, '1']
- [siso_path, '0', channel_output, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
