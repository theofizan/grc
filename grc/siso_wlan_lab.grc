options:
  parameters:
    id: siso_wlan_lab
    title: 'SISO Wi-Fi PHY: waveform -> FIR/CFO/AWGN -> trained RX -> BER/EVM'
    author: Antenna benchmark project
    description: Complete known-burst SISO PHY with fixed active TX power and live pre-FEC BER/EVM. No autonomous acquisition or MAC.
    generate_options: qt_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from antenna_bench.paths import ROOT
      from antenna_bench.live import test_bits, wlan_reference, burst_waveform, reference_symbols, parse_taps
      from antenna_bench.wlan import wlan_constellation
      from gnuradio import digital
  states: {}
- name: rate_index
  id: parameter
  parameters:
    value: '2'
    type: intx
    label: Legacy rate index (0-7)
  states: {}
- name: snr_db
  id: parameter
  parameters:
    value: '25'
    type: eng_float
    label: TX active-PPDU reference SNR (dB)
  states: {}
- name: path_loss_db
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: SISO power loss (dB)
  states: {}
- name: packet_count
  id: parameter
  parameters:
    value: '0'
    type: intx
    label: PHY bursts (0 = continuous)
  states: {}
- name: pace
  id: parameter
  parameters:
    value: '1000000'
    type: eng_float
    label: Playback samples per wall-clock second
  states: {}
- name: cfo_hz
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: Carrier offset (Hz)
  states: {}
- name: channel_taps
  id: parameter
  parameters:
    value: 1+0j
    type: str
    label: Causal SISO FIR taps
  states: {}
- name: correct_cfo
  id: parameter
  parameters:
    value: '1'
    type: intx
    label: STF/LTF CFO correction (0/1)
  states: {}
- name: pilot_tracking
  id: parameter
  parameters:
    value: '1'
    type: intx
    label: Pilot phase correction (0/1)
  states: {}
- name: reference
  id: variable
  parameters:
    value: wlan_reference(rate_index)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: order
  id: variable
  parameters:
    value: int(reference['order'])
  states: {}
- name: k
  id: variable
  parameters:
    value: int(math.log2(order))
  states: {}
- name: channel_gain
  id: variable
  parameters:
    value: 10**(-path_loss_db/20)
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: 10**(-snr_db/20)
  states: {}
- name: constellation_object
  id: variable
  parameters:
    value: digital.constellation_calcdist(wlan_constellation(order).tolist(),list(range(order)),1,1,digital.constellation.NO_NORMALIZATION).base()
  states: {}
- name: tx_waveform
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: burst_waveform(rate_index).tolist()
    repeat: 'True'
  states: {}
- name: finite_tx
  id: blocks_head
  parameters:
    type: complex
    num_items: packet_count*len(burst_waveform(rate_index)) if packet_count>0 else 2**60
  states: {}
- name: pace_tx
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: pace
  states: {}
- name: siso_fir
  id: fir_filter_xxx
  parameters:
    type: ccc
    decim: '1'
    taps: '[channel_gain*t for t in parse_taps(channel_taps)]'
  states: {}
- name: carrier_offset
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*cfo_hz/sample_rate
  states: {}
- name: awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_voltage
    seed: '20261017'
  states: {}
- name: channel_output
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: extract_bursts
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: reference['tx_packet'].size
    n: len(burst_waveform(rate_index))
    offset: '0'
  states: {}
- name: burst_receiver
  id: epy_block
  parameters:
    _source_code: |
      import antenna_bench.gr_metrics as metrics

      class blk(metrics.BurstReceiver):
          def __init__(self, rate_index=2, correct_cfo=True, pilot_tracking=True, report_path=""):
              super().__init__(rate_index, correct_cfo, pilot_tracking, report_path)
    rate_index: rate_index
    correct_cfo: bool(correct_cfo)
    pilot_tracking: bool(pilot_tracking)
    report_path: str(ROOT / 'results/live/siso_wlan_receiver.json')
  states: {}
- name: demap
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_object
  states: {}
- name: rx_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: tx_reference
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: reference_symbols(rate_index).tolist()
    repeat: 'True'
  states: {}
- name: finite_reference
  id: blocks_head
  parameters:
    type: complex
    num_items: packet_count*reference_symbols(rate_index).size if packet_count>0 else 2**60
  states: {}
- name: tx_decisions
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_object
  states: {}
- name: tx_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: ber_meter
  id: epy_block
  parameters:
    _source_code: |
      import antenna_bench.gr_metrics as metrics

      class blk(metrics.BitErrorMeter):
          def __init__(self, report_path="", run_config=None):
              super().__init__(report_path, run_config)
    report_path: str(ROOT / 'results/live/siso_wlan_ber.json')
    run_config: dict(model='SISO known-burst Wi-Fi',rate_index=rate_index,tx_reference_snr_db=snr_db,path_loss_db=path_loss_db,cfo_hz=cfo_hz,channel_taps=channel_taps,correct_cfo=correct_cfo,pilot_tracking=pilot_tracking)
  states: {}
- name: evm_meter
  id: epy_block
  parameters:
    _source_code: |
      import antenna_bench.gr_metrics as metrics

      class blk(metrics.EvmMeter):
          def __init__(self, report_path="", run_config=None):
              super().__init__(report_path, run_config)
    report_path: str(ROOT / 'results/live/siso_wlan_evm.json')
    run_config: dict(model='SISO known-burst Wi-Fi',rate_index=rate_index,tx_reference_snr_db=snr_db,path_loss_db=path_loss_db,cfo_hz=cfo_hz,channel_taps=channel_taps,correct_cfo=correct_cfo,pilot_tracking=pilot_tracking)
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    num_tabs: '3'
    label0: Metrics and constellation
    label1: 'TX waveform: spectrum / waterfall / time'
    label2: 'RX waveform: spectrum / waterfall / time'
  states: {}
- name: tx_scope
  id: qtgui_sink_x
  parameters:
    type: complex
    name: TX waveform | complex baseband; relative FFT level
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: sample_rate
    rate: '5'
    plotconst: 'False'
    gui_hint: views@1:0,0,1,2
  states: {}
- name: rx_scope
  id: qtgui_sink_x
  parameters:
    type: complex
    name: RX waveform | before equalization; relative FFT level
    fftsize: '1024'
    wintype: window.WIN_HANN
    fc: '0'
    bw: sample_rate
    rate: '5'
    plotconst: 'False'
    gui_hint: views@2:0,0,1,2
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: SISO equalized symbols and known reference
    size: '1024'
    grid: 'True'
    xmin: '-2.0'
    xmax: '2.0'
    ymin: '-2.0'
    ymax: '2.0'
    nconnections: '2'
    label1: RX equalized DATA
    label2: TX reference DATA
    marker2: '8'
    alpha1: '0.5'
    gui_hint: views@0:1,0,1,2
  states: {}
- name: ber_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: Cumulative pre-FEC BER
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    label1: Cumulative pre-FEC BER
    unit1: errors/bit
    gui_hint: views@0:0,0,1,1
  states: {}
- name: evm_display
  id: qtgui_number_sink
  parameters:
    type: float
    name: Pooled RMS EVM
    graph_type: qtgui.NUM_GRAPH_NONE
    min: '0'
    max: '100'
    label1: Pooled RMS EVM
    unit1: '%'
    gui_hint: views@0:0,1,1,1
  states: {}
- name: scope
  id: note
  parameters:
    note: 'SISO LEGACY Wi-Fi PHY LAB: 1 TX / 1 RX; fixed rate/length and known burst schedule. No MAC, ACK or retries.'
  states: {}
- name: power
  id: note
  parameters:
    note: TX active-PPDU mean |x|^2=1 at every rate; snr_db sets fixed noise power against that TX reference, not measured RX SNR.
  states: {}
- name: receiver_note
  id: note
  parameters:
    note: Receiver contains STF/LTF CFO correction, LTF-only ZF, CP removal/FFT and pilot phase tracking. Double-click Python block; see docs/SISO_LABS.md.
  states: {}
- name: pacing
  id: note
  parameters:
    note: Logical sample rate=20 Msps. pace controls wall-clock playback only. packet_count=0 is continuous. Stop saves BER/EVM and receiver JSON.
  states: {}

connections:
- [tx_waveform, '0', finite_tx, '0']
- [finite_tx, '0', pace_tx, '0']
- [pace_tx, '0', siso_fir, '0']
- [siso_fir, '0', carrier_offset, '0']
- [carrier_offset, '0', channel_output, '0']
- [awgn, '0', channel_output, '1']
- [channel_output, '0', extract_bursts, '0']
- [extract_bursts, '0', burst_receiver, '0']
- [burst_receiver, '0', demap, '0']
- [demap, '0', rx_bits, '0']
- [tx_reference, '0', finite_reference, '0']
- [finite_reference, '0', tx_decisions, '0']
- [tx_decisions, '0', tx_bits, '0']
- [tx_bits, '0', ber_meter, '0']
- [rx_bits, '0', ber_meter, '1']
- [finite_reference, '0', evm_meter, '0']
- [burst_receiver, '0', evm_meter, '1']
- [pace_tx, '0', tx_scope, '0']
- [channel_output, '0', rx_scope, '0']
- [burst_receiver, '0', constellation, '0']
- [finite_reference, '0', constellation, '1']
- [ber_meter, '0', ber_display, '0']
- [evm_meter, '0', evm_display, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
