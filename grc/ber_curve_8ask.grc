options:
  parameters:
    id: ber_curve_8ask
    title: 8-ASK BER vs Eb/N0 | stock blocks
    generate_options: qt_gui
    output_language: python
    author: Antenna benchmark
  states: {}

blocks:
- name: const
  id: variable_constellation_rect
  parameters:
    sym_map: '[0, 1, 2, 3, 4, 5, 6, 7]'
    const_points: '[-7, -5, -3, -1, 1, 3, 5, 7]'
    rot_sym: '1'
    real_sect: '8'
    imag_sect: '1'
    w_real_sect: '2'
    w_imag_sect: '1'
  states: {}
- name: k
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    value: 1e6
    type: eng_float
    label: Symbol rate (symbols/s)
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: symbol_rate*k
  states: {}
- name: symbol_rms
  id: variable
  parameters:
    value: (sum(abs(p)**2 for p in const.points())/len(const.points()))**0.5
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: eq_algorithm
  id: variable_adaptive_algorithm
  parameters:
    type: lms
    cons: const
    step_size: eq_step/(eq_taps*symbol_rms**2)
  states: {}
- name: eq_taps
  id: parameter
  parameters:
    value: '11'
    type: intx
    label: Adaptive equalizer taps
  states: {}
- name: eq_step
  id: parameter
  parameters:
    value: '0.01'
    type: eng_float
    label: NLMS adaptation step
  states: {}
- name: eq_delay_symbols
  id: variable
  parameters:
    value: (eq_taps-1)//2
  states: {}
- name: reference_delay
  id: parameter
  parameters:
    value: '102'
    type: intx
    label: TX reference delay (bits)
  states: {}
- name: warmup_bits
  id: variable
  parameters:
    value: '50000'
  states: {}
- name: tx_power_dbm
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: TX average conducted power (dBm)
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    value: 10**(tx_power_dbm/20.0)
  states: {}
- name: path_loss_db
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: Net path loss including gains/losses (dB)
  states: {}
- name: path_gain
  id: variable
  parameters:
    value: 10**(-path_loss_db/20.0)
  states: {}
- name: chart_math
  id: import
  parameters:
    imports: |-
      import math
      import numpy
  states: {}
- name: ebno_db
  id: variable
  parameters:
    value: '[6, 8, 10, 12, 14, 16, 18, 20]'
  states: {}
- name: noise_volts
  id: variable
  parameters:
    value: list(tx_amplitude*path_gain*10**(-(numpy.array(ebno_db) - 10*math.log10(samp_rate/bit_rate))/20))
  states: {}
- name: min_errors
  id: parameter
  parameters:
    value: '100'
    type: intx
    label: Bit errors to collect per point
  states: {}
- name: ber_floor_log10
  id: parameter
  parameters:
    value: '-7'
    type: eng_float
    label: Stop a point below BER 10^x
  states: {}
- name: plot_update_s
  id: parameter
  parameters:
    value: '0.5'
    type: eng_float
    label: Plot refresh interval (s)
  states: {}
- name: sim_speed
  id: parameter
  parameters:
    value: '100'
    type: eng_float
    label: Simulation speed limit (x real time)
  states: {}
- name: section_controls
  id: note
  parameters:
    note: 'CONTROLS: EB/N0 POINTS AND MODEM'
  states: {}
- name: section_transmitter
  id: note
  parameters:
    note: TRANSMITTER
  states: {}
- name: random_bytes
  id: analog_random_source_x
  parameters:
    type: byte
    min: '0'
    max: '256'
    num_samps: '32768'
    repeat: 'True'
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    samples_per_symbol: sps
    excess_bw: alpha
  states: {}
- name: tx_power
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: tx_amplitude/symbol_rms
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    type: complex
    samples_per_second: samp_rate*sim_speed
  states: {}
- name: tx_link
  id: virtual_sink
  parameters:
    stream_id: tx_waveform
  states: {}
- name: reference_link
  id: virtual_sink
  parameters:
    stream_id: tx_bytes
  states: {}
- name: reference_source
  id: virtual_source
  parameters:
    stream_id: tx_bytes
  states: {}
- name: unpack_tx
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    type: byte
    delay: reference_delay
  states: {}
- name: skip_tx
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_tx
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: tx_bits_link
  id: virtual_sink
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: section_receivers
  id: note
  parameters:
    note: CHANNEL AND RECEIVER, ONE ROW PER EB/N0 POINT
  states: {}
- name: tx_in_0
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_0
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[0]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '100'
  states: {}
- name: rx_level_0
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_0
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_0
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_0
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_0
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_0
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_0
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_0
  states: {}
- name: tx_in_1
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_1
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[1]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '101'
  states: {}
- name: rx_level_1
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_1
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_1
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_1
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_1
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_1
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_1
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_1
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_1
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_1
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_1
  states: {}
- name: tx_in_2
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_2
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[2]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '102'
  states: {}
- name: rx_level_2
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_2
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_2
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_2
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_2
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_2
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_2
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_2
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_2
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_2
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_2
  states: {}
- name: tx_in_3
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_3
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[3]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '103'
  states: {}
- name: rx_level_3
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_3
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_3
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_3
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_3
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_3
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_3
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_3
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_3
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_3
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_3
  states: {}
- name: tx_in_4
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_4
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[4]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '104'
  states: {}
- name: rx_level_4
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_4
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_4
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_4
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_4
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_4
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_4
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_4
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_4
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_4
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_4
  states: {}
- name: tx_in_5
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_5
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[5]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '105'
  states: {}
- name: rx_level_5
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_5
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_5
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_5
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_5
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_5
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_5
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_5
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_5
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_5
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_5
  states: {}
- name: tx_in_6
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_6
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[6]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '106'
  states: {}
- name: rx_level_6
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_6
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_6
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_6
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_6
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_6
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_6
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_6
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_6
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_6
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_6
  states: {}
- name: tx_in_7
  id: virtual_source
  parameters:
    stream_id: tx_waveform
  states: {}
- name: channel_7
  id: channels_channel_model
  parameters:
    noise_voltage: noise_volts[7]
    freq_offset: '0'
    epsilon: '1'
    taps: '[path_gain]'
    seed: '107'
  states: {}
- name: rx_level_7
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: 1.0/(tx_amplitude*path_gain)
  states: {}
- name: clock_sync_7
  id: digital_pfb_clock_sync_xxx
  parameters:
    type: ccf
    sps: sps
    loop_bw: timing_bw
    taps: rrc_taps
    filter_size: nfilts
    init_phase: '16'
    max_dev: '1.5'
    osps: '1'
  states: {}
- name: rx_scale_7
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: symbol_rms
  states: {}
- name: equalizer_7
  id: digital_linear_equalizer
  parameters:
    num_taps: eq_taps
    sps: '1'
    alg: eq_algorithm
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: decoder_7
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: diff_decoder_7
  id: digital_diff_decoder_bb
  parameters:
    modulus: '8'
    coding: digital.DIFF_DIFFERENTIAL
  states: {}
- name: unpack_rx_7
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: skip_rx_7
  id: blocks_skiphead
  parameters:
    type: byte
    num_items: warmup_bits
  states: {}
- name: pack_rx_7
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: rx_bits_7
  id: virtual_sink
  parameters:
    stream_id: rx_bytes_7
  states: {}
- name: section_ber_curve
  id: note
  parameters:
    note: BER CURVE
  states: {}
- name: ber_curve
  id: qtgui_bercurve_sink
  parameters:
    esno: ebno_db
    berminerrors: min_errors
    berlimit: ber_floor_log10
    ymin: '-7'
    update_time: plot_update_s
    label1: '"8-ASK measured"'
    width1: '2'
    bus_structure_sink: '[[0, 1, 2, 3, 4, 5, 6, 7, 8, 9, 10, 11, 12, 13, 14, 15]]'
  states: {}
- name: tx_ref_0
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_0
  id: virtual_source
  parameters:
    stream_id: rx_bytes_0
  states: {}
- name: tx_ref_1
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_1
  id: virtual_source
  parameters:
    stream_id: rx_bytes_1
  states: {}
- name: tx_ref_2
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_2
  id: virtual_source
  parameters:
    stream_id: rx_bytes_2
  states: {}
- name: tx_ref_3
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_3
  id: virtual_source
  parameters:
    stream_id: rx_bytes_3
  states: {}
- name: tx_ref_4
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_4
  id: virtual_source
  parameters:
    stream_id: rx_bytes_4
  states: {}
- name: tx_ref_5
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_5
  id: virtual_source
  parameters:
    stream_id: rx_bytes_5
  states: {}
- name: tx_ref_6
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_6
  id: virtual_source
  parameters:
    stream_id: rx_bytes_6
  states: {}
- name: tx_ref_7
  id: virtual_source
  parameters:
    stream_id: tx_reference_bytes
  states: {}
- name: rx_out_7
  id: virtual_source
  parameters:
    stream_id: rx_bytes_7
  states: {}
- name: equalizer_initial_taps
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      # Start every row's adaptive equalizer at a centered identity filter.
      for i in range(8):
          getattr(self, 'equalizer_%d' % i).set_taps([0j]*((self.eq_taps-1)//2)+[1+0j]+[0j]*(self.eq_taps//2))
  states: {}
- name: curve_title
  id: snippet
  parameters:
    section: main_after_init
    code: |-
      self.ber_curve.set_title('8-ASK BER vs Eb/N0 (x axis: Eb/N0 in dB per bit). Red: BPSK/QPSK theory')
      self.resize(1000, 700)
  states: {}

connections:
- [random_bytes, '0', modulator, '0']
- [modulator, '0', tx_power, '0']
- [tx_power, '0', throttle, '0']
- [throttle, '0', tx_link, '0']
- [random_bytes, '0', reference_link, '0']
- [reference_source, '0', unpack_tx, '0']
- [unpack_tx, '0', delay, '0']
- [delay, '0', skip_tx, '0']
- [skip_tx, '0', pack_tx, '0']
- [pack_tx, '0', tx_bits_link, '0']
- [tx_in_0, '0', channel_0, '0']
- [channel_0, '0', rx_level_0, '0']
- [rx_level_0, '0', clock_sync_0, '0']
- [clock_sync_0, '0', rx_scale_0, '0']
- [rx_scale_0, '0', equalizer_0, '0']
- [equalizer_0, '0', decoder_0, '0']
- [decoder_0, '0', diff_decoder_0, '0']
- [diff_decoder_0, '0', unpack_rx_0, '0']
- [unpack_rx_0, '0', skip_rx_0, '0']
- [skip_rx_0, '0', pack_rx_0, '0']
- [pack_rx_0, '0', rx_bits_0, '0']
- [tx_in_1, '0', channel_1, '0']
- [channel_1, '0', rx_level_1, '0']
- [rx_level_1, '0', clock_sync_1, '0']
- [clock_sync_1, '0', rx_scale_1, '0']
- [rx_scale_1, '0', equalizer_1, '0']
- [equalizer_1, '0', decoder_1, '0']
- [decoder_1, '0', diff_decoder_1, '0']
- [diff_decoder_1, '0', unpack_rx_1, '0']
- [unpack_rx_1, '0', skip_rx_1, '0']
- [skip_rx_1, '0', pack_rx_1, '0']
- [pack_rx_1, '0', rx_bits_1, '0']
- [tx_in_2, '0', channel_2, '0']
- [channel_2, '0', rx_level_2, '0']
- [rx_level_2, '0', clock_sync_2, '0']
- [clock_sync_2, '0', rx_scale_2, '0']
- [rx_scale_2, '0', equalizer_2, '0']
- [equalizer_2, '0', decoder_2, '0']
- [decoder_2, '0', diff_decoder_2, '0']
- [diff_decoder_2, '0', unpack_rx_2, '0']
- [unpack_rx_2, '0', skip_rx_2, '0']
- [skip_rx_2, '0', pack_rx_2, '0']
- [pack_rx_2, '0', rx_bits_2, '0']
- [tx_in_3, '0', channel_3, '0']
- [channel_3, '0', rx_level_3, '0']
- [rx_level_3, '0', clock_sync_3, '0']
- [clock_sync_3, '0', rx_scale_3, '0']
- [rx_scale_3, '0', equalizer_3, '0']
- [equalizer_3, '0', decoder_3, '0']
- [decoder_3, '0', diff_decoder_3, '0']
- [diff_decoder_3, '0', unpack_rx_3, '0']
- [unpack_rx_3, '0', skip_rx_3, '0']
- [skip_rx_3, '0', pack_rx_3, '0']
- [pack_rx_3, '0', rx_bits_3, '0']
- [tx_in_4, '0', channel_4, '0']
- [channel_4, '0', rx_level_4, '0']
- [rx_level_4, '0', clock_sync_4, '0']
- [clock_sync_4, '0', rx_scale_4, '0']
- [rx_scale_4, '0', equalizer_4, '0']
- [equalizer_4, '0', decoder_4, '0']
- [decoder_4, '0', diff_decoder_4, '0']
- [diff_decoder_4, '0', unpack_rx_4, '0']
- [unpack_rx_4, '0', skip_rx_4, '0']
- [skip_rx_4, '0', pack_rx_4, '0']
- [pack_rx_4, '0', rx_bits_4, '0']
- [tx_in_5, '0', channel_5, '0']
- [channel_5, '0', rx_level_5, '0']
- [rx_level_5, '0', clock_sync_5, '0']
- [clock_sync_5, '0', rx_scale_5, '0']
- [rx_scale_5, '0', equalizer_5, '0']
- [equalizer_5, '0', decoder_5, '0']
- [decoder_5, '0', diff_decoder_5, '0']
- [diff_decoder_5, '0', unpack_rx_5, '0']
- [unpack_rx_5, '0', skip_rx_5, '0']
- [skip_rx_5, '0', pack_rx_5, '0']
- [pack_rx_5, '0', rx_bits_5, '0']
- [tx_in_6, '0', channel_6, '0']
- [channel_6, '0', rx_level_6, '0']
- [rx_level_6, '0', clock_sync_6, '0']
- [clock_sync_6, '0', rx_scale_6, '0']
- [rx_scale_6, '0', equalizer_6, '0']
- [equalizer_6, '0', decoder_6, '0']
- [decoder_6, '0', diff_decoder_6, '0']
- [diff_decoder_6, '0', unpack_rx_6, '0']
- [unpack_rx_6, '0', skip_rx_6, '0']
- [skip_rx_6, '0', pack_rx_6, '0']
- [pack_rx_6, '0', rx_bits_6, '0']
- [tx_in_7, '0', channel_7, '0']
- [channel_7, '0', rx_level_7, '0']
- [rx_level_7, '0', clock_sync_7, '0']
- [clock_sync_7, '0', rx_scale_7, '0']
- [rx_scale_7, '0', equalizer_7, '0']
- [equalizer_7, '0', decoder_7, '0']
- [decoder_7, '0', diff_decoder_7, '0']
- [diff_decoder_7, '0', unpack_rx_7, '0']
- [unpack_rx_7, '0', skip_rx_7, '0']
- [skip_rx_7, '0', pack_rx_7, '0']
- [pack_rx_7, '0', rx_bits_7, '0']
- [tx_ref_0, '0', ber_curve, '0']
- [rx_out_0, '0', ber_curve, '1']
- [tx_ref_1, '0', ber_curve, '2']
- [rx_out_1, '0', ber_curve, '3']
- [tx_ref_2, '0', ber_curve, '4']
- [rx_out_2, '0', ber_curve, '5']
- [tx_ref_3, '0', ber_curve, '6']
- [rx_out_3, '0', ber_curve, '7']
- [tx_ref_4, '0', ber_curve, '8']
- [rx_out_4, '0', ber_curve, '9']
- [tx_ref_5, '0', ber_curve, '10']
- [rx_out_5, '0', ber_curve, '11']
- [tx_ref_6, '0', ber_curve, '12']
- [rx_out_6, '0', ber_curve, '13']
- [tx_ref_7, '0', ber_curve, '14']
- [rx_out_7, '0', ber_curve, '15']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
