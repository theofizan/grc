options:
  parameters:
    author: Antenna benchmark
    generate_options: qt_gui
    id: single_carrier_4ask
    output_language: python
    title: 4ASK single carrier | stock blocks
  states: {}

blocks:
- name: alpha
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: ber_window
  id: variable
  parameters:
    value: '10000'
  states: {}
- name: bit_rate
  id: variable
  parameters:
    value: symbol_rate*k
  states: {}
- name: const
  id: variable_constellation_rect
  parameters:
    const_points: '[-3, -1, 1, 3]'
    imag_sect: '1'
    real_sect: '4'
    rot_sym: '1'
    sym_map: '[0, 1, 2, 3]'
    w_imag_sect: '1'
    w_real_sect: '2'
  states: {}
- name: ebno_rx_db
  id: variable
  parameters:
    value: snr_rx_db+10*math.log10(samp_rate/bit_rate)
  states: {}
- name: eq_algorithm
  id: variable_adaptive_algorithm
  parameters:
    cons: const
    step_size: eq_step/(eq_taps*symbol_rms**2)
    type: lms
  states: {}
- name: eq_delay_symbols
  id: variable
  parameters:
    value: (eq_taps-1)//2
  states: {}
- name: esno_rx_db
  id: variable
  parameters:
    value: snr_rx_db+10*math.log10(samp_rate/symbol_rate)
  states: {}
- name: expected_rx_dbm
  id: variable
  parameters:
    value: tx_power_dbm-path_loss_db
  states: {}
- name: eye_synthesis_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(sps,sps,1.0,alpha,11*sps)
  states: {}
- name: k
  id: variable
  parameters:
    value: const.bits_per_symbol()
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: '32'
  states: {}
- name: noise_volt
  id: variable
  parameters:
    value: 10**(rx_noise_dbm/20.0) if noise_enabled else 0.0
  states: {}
- name: path_gain
  id: variable
  parameters:
    value: 10**(-path_loss_db/20.0)
  states: {}
- name: rrc_bandwidth
  id: variable
  parameters:
    value: symbol_rate*(1+alpha)
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(nfilts, nfilts*sps, 1.0, alpha, 11*sps*nfilts)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: symbol_rate*sps
  states: {}
- name: snr_rx_db
  id: variable
  parameters:
    value: expected_rx_dbm-rx_noise_dbm if noise_enabled else float('inf')
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: symbol_rms
  id: variable
  parameters:
    value: (sum(abs(p)**2 for p in const.points())/len(const.points()))**0.5
  states: {}
- name: timing_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: tx_amplitude
  id: variable
  parameters:
    value: 10**(tx_power_dbm/20.0)
  states: {}
- name: warmup_bits
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: adaptive_tap_vectors_link
  id: virtual_sink
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: after_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: eye_synthesis_taps
    type: ccf
  states: {}
- name: after_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: after_i_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@2:2,1,1,1
    label1: After EQ I | reconstructed
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: AFTER I | reconstructed
  states: {}
- name: after_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: after_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: after_q_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@4:2,1,1,1
    label1: After EQ Q | reconstructed
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: AFTER Q | reconstructed
  states: {}
- name: before_eq_constellation
  id: qtgui_const_sink_x
  parameters:
    grid: 'True'
    gui_hint: views@0:1,1,1,1
    name: 'Middle: timed symbols before adaptive EQ'
    size: '1024'
    type: complex
    update_time: plot_update_s
  states: {}
- name: before_eq_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: ber_display
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: views@0:0,0,1,1
    label1: Bit error ratio
    min: '0'
    name: BER | latest 10000 compared bits
    type: float
    unit1: errors/bit
    update_time: plot_update_s
  states: {}
- name: ber_history
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@5:1,0,1,1
    label1: BER
    name: BER per compared-bit window
    size: '128'
    srate: bit_rate/ber_window
    type: float
    update_time: plot_update_s
    ylabel: Bit error ratio
    ymin: '0'
    yunit: ''
  states: {}
- name: ber_link
  id: virtual_sink
  parameters:
    stream_id: ber_history
  states: {}
- name: ber_plot_input
  id: virtual_source
  parameters:
    stream_id: ber_history
  states: {}
- name: ber_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/ber_window
    type: float
  states: {}
- name: channel
  id: channels_channel_model
  parameters:
    epsilon: '1'
    freq_offset: '0'
    noise_voltage: noise_volt
    seed: '42'
    taps: '[path_gain/(1+channel_echo**2)**0.5]+[0j]*(sps-1)+[path_gain*channel_echo/(1+channel_echo**2)**0.5]'
  states: {}
- name: channel_echo
  id: parameter
  parameters:
    label: One-symbol echo voltage ratio
    type: eng_float
    value: '0'
  states: {}
- name: chart_math
  id: import
  parameters:
    imports: |-
      import math
      import numpy
  states: {}
- name: clock_sync
  id: digital_pfb_clock_sync_xxx
  parameters:
    filter_size: nfilts
    init_phase: '16'
    loop_bw: timing_bw
    max_dev: '1.5'
    osps: '1'
    sps: sps
    taps: rrc_taps
    type: ccf
  states: {}
- name: constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.3'
    alpha3: '0.5'
    color2: '"black"'
    color3: '"dark green"'
    grid: 'True'
    gui_hint: views@0:2,0,1,1
    label1: RX symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    marker2: '8'
    name: After adaptive LMS equalization | symbols and guides
    nconnections: '3'
    size: '1024'
    type: complex
    update_time: plot_update_s
  states: {}
- name: constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: decoded_link
  id: virtual_sink
  parameters:
    stream_id: decoded
  states: {}
- name: decoded_source
  id: virtual_source
  parameters:
    stream_id: decoded
  states: {}
- name: decoder
  id: digital_constellation_decoder_cb
  parameters:
    constellation: const
  states: {}
- name: delay
  id: blocks_delay
  parameters:
    delay: reference_delay
    type: byte
  states: {}
- name: diff_decoder
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: eq_error_trace
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@5:2,0,1,1
    label1: Decision-directed EVM
    name: Per-symbol equalized EVM (%)
    size: '128'
    srate: symbol_rate
    type: float
    update_time: plot_update_s
    ylabel: EVM
    yunit: '%'
  states: {}
- name: eq_error_trace_input
  id: virtual_source
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: eq_evm_history
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@0:2,1,1,1
    label1: Decision-directed EVM
    name: Equalized decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    type: float
    update_time: plot_update_s
    ylabel: EVM
    yunit: '%'
  states: {}
- name: eq_step
  id: parameter
  parameters:
    label: NLMS adaptation step
    type: eng_float
    value: '0.01'
  states: {}
- name: eq_tap_decimator
  id: blocks_keep_one_in_n
  parameters:
    n: '1000'
    type: complex
    vlen: eq_taps
  states: {}
- name: eq_tap_decimator_input
  id: virtual_source
  parameters:
    stream_id: adaptive_tap_vectors
  states: {}
- name: eq_tap_magnitudes
  id: blocks_complex_to_mag
  parameters:
    vlen: eq_taps
  states: {}
- name: eq_tap_plot
  id: qtgui_vector_sink_f
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@5:2,1,1,1
    name: Adaptive LMS tap magnitudes | updated during convergence
    update_time: plot_update_s
    vlen: eq_taps
    x_axis_label: Tap index
    x_start: '0'
    x_step: '1'
    y_axis_label: Magnitude
  states: {}
- name: eq_taps
  id: parameter
  parameters:
    label: Adaptive equalizer taps
    type: intx
    value: '11'
  states: {}
- name: equalizer
  id: digital_linear_equalizer
  parameters:
    alg: eq_algorithm
    num_taps: eq_taps
    sps: '1'
    training_sequence: '[]'
    training_start_tag: ''
  states: {}
- name: equalizer_initial_taps
  id: snippet
  parameters:
    code: self.equalizer.set_taps([0j]*((self.eq_taps-1)//2)+[1+0j]+[0j]*(self.eq_taps//2))
    section: main_after_init
  states: {}
- name: errors_float
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: evm
  id: digital_meas_evm_cc
  parameters:
    cons: const
    meas_type: digital.evm_measurement_t.EVM_PERCENT
  states: {}
- name: evm_circles
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: '[p+symbol_rms*evm_guide_percent/100*complex(math.cos(t),math.sin(t)) for p in const.points() for t in numpy.linspace(0,2*math.pi,64,endpoint=False)]'
  states: {}
- name: evm_circles_link
  id: virtual_sink
  parameters:
    stream_id: guide_circles
  states: {}
- name: evm_display
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_NONE
    gui_hint: views@0:0,1,1,1
    label1: Decision-directed EVM
    max: '100'
    min: '0'
    name: Decision-directed RMS EVM
    type: float
    unit1: '%'
    update_time: plot_update_s
  states: {}
- name: evm_guide_percent
  id: parameter
  parameters:
    label: Constellation guide radius (% RMS)
    type: eng_float
    value: '5'
  states: {}
- name: evm_history
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@5:1,1,1,1
    label1: Decision-directed EVM
    name: Smoothed decision-directed RMS EVM (%)
    size: '128'
    srate: symbol_rate
    type: float
    update_time: plot_update_s
    ylabel: EVM
    yunit: '%'
  states: {}
- name: evm_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: evm_link
  id: virtual_sink
  parameters:
    stream_id: evm_history
  states: {}
- name: evm_meter_history_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: evm_per_symbol_link
  id: virtual_sink
  parameters:
    stream_id: evm_per_symbol
  states: {}
- name: evm_plot_input
  id: virtual_source
  parameters:
    stream_id: evm_history
  states: {}
- name: evm_rms
  id: blocks_rms_xx
  parameters:
    alpha: '0.001'
    type: float
  states: {}
- name: eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@2:1,1,1,1
    label1: RX I | raw channel output
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: RX in-phase amplitude
  states: {}
- name: eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: eye_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: eye_q_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: eye_quadrature
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@4:1,1,1,1
    label1: RX Q | raw channel output
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: RX quadrature amplitude
  states: {}
- name: ideal_symbols
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: complex
    vector: const.points()
  states: {}
- name: ideal_symbols_link
  id: virtual_sink
  parameters:
    stream_id: ideal_points
  states: {}
- name: integrate
  id: blocks_integrate_xx
  parameters:
    decim: ber_window
    type: float
  states: {}
- name: middle_eye_reconstruction
  id: interp_fir_filter_xxx
  parameters:
    interp: sps
    taps: eye_synthesis_taps
    type: ccf
  states: {}
- name: middle_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: middle_i_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@2:2,0,1,1
    label1: Middle I | before EQ, reconstructed
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: MIDDLE I | reconstructed
  states: {}
- name: middle_input
  id: virtual_source
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: middle_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: middle_q_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@4:2,0,1,1
    label1: Middle Q | before EQ, reconstructed
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: MIDDLE Q | reconstructed
  states: {}
- name: modulator
  id: digital_constellation_modulator
  parameters:
    constellation: const
    differential: 'True'
    excess_bw: alpha
    samples_per_symbol: sps
  states: {}
- name: noise_enabled
  id: parameter
  parameters:
    label: Receiver noise enabled (0/1)
    type: intx
    value: '1'
  states: {}
- name: path_loss_db
  id: parameter
  parameters:
    label: Net path loss including gains/losses (dB)
    type: eng_float
    value: '90'
  states: {}
- name: peak_input
  id: virtual_source
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: pre_eq_link
  id: virtual_sink
  parameters:
    stream_id: pre_eq_symbols
  states: {}
- name: random_bytes
  id: analog_random_source_x
  parameters:
    max: '256'
    min: '0'
    num_samps: '32768'
    repeat: 'True'
    type: byte
  states: {}
- name: reference_delay
  id: parameter
  parameters:
    label: TX reference delay (bits)
    type: intx
    value: '68'
  states: {}
- name: reference_link
  id: virtual_sink
  parameters:
    stream_id: reference
  states: {}
- name: reference_source
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: rx_dbm
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: rx_ebno
  id: blocks_add_const_vxx
  parameters:
    const: '-path_loss_db-rx_noise_dbm+10*math.log10(samp_rate/bit_rate) if noise_enabled else float(''inf'')'
    type: float
  states: {}
- name: rx_ebno_input
  id: virtual_source
  parameters:
    stream_id: sensed_tx_dbm
  states: {}
- name: rx_iq_link
  id: virtual_sink
  parameters:
    stream_id: rx_iq
  states: {}
- name: rx_level
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/(tx_amplitude*path_gain)
    type: complex
  states: {}
- name: rx_meter_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: rx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: rx_noise_dbm
  id: parameter
  parameters:
    label: RX noise over sample bandwidth (dBm)
    type: eng_float
    value: '-100'
  states: {}
- name: rx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/4096
    type: float
  states: {}
- name: rx_power_sum
  id: blocks_integrate_xx
  parameters:
    decim: '4096'
    type: float
  states: {}
- name: rx_scale
  id: blocks_multiply_const_vxx
  parameters:
    const: symbol_rms
    type: complex
  states: {}
- name: rx_snr
  id: blocks_add_const_vxx
  parameters:
    const: '-path_loss_db-rx_noise_dbm if noise_enabled else float(''inf'')'
    type: float
  states: {}
- name: rx_snr_input
  id: virtual_source
  parameters:
    stream_id: sensed_tx_dbm
  states: {}
- name: scope
  id: note
  parameters:
    note: 'SISO single carrier, RRC pulse shaping. 4ASK, 4 samples/symbol. No carrier recovery: leave frequency offset=0 and epsilon=1 for scored BER. Delay calibrated for this filter/clock configuration. See README.md.'
  states: {}
- name: section_ber
  id: note
  parameters:
    note: BER MEASUREMENT
  states: {}
- name: section_channel
  id: note
  parameters:
    note: CHANNEL
  states: {}
- name: section_controls
  id: note
  parameters:
    note: CONTROLS & RF SETTINGS
  states: {}
- name: section_extra_plots
  id: note
  parameters:
    note: LIVE WAVEFORM & ADAPTATION MONITORS
  states: {}
- name: section_eyes
  id: note
  parameters:
    note: 'EYE COMPARISON: MIDDLE / AFTER EQ / TX'
  states: {}
- name: section_power
  id: note
  parameters:
    note: LINK BUDGET & POWER METERS
  states: {}
- name: section_pre_eq
  id: note
  parameters:
    note: BEFORE EQUALIZATION
  states: {}
- name: section_receiver
  id: note
  parameters:
    note: RECEIVER
  states: {}
- name: section_reference
  id: note
  parameters:
    note: TX SYMBOL REFERENCE & EVM GUIDES
  states: {}
- name: section_rx_diagnostics
  id: note
  parameters:
    note: RX DIAGNOSTICS
  states: {}
- name: section_transmitter
  id: note
  parameters:
    note: TRANSMITTER
  states: {}
- name: skip_rx
  id: blocks_skiphead
  parameters:
    num_items: warmup_bits
    type: byte
  states: {}
- name: skip_tx
  id: blocks_skiphead
  parameters:
    num_items: warmup_bits
    type: byte
  states: {}
- name: spectrum
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: views@1:2,0,1,1
    label1: RX
    label2: TX
    name: TX and RX baseband spectrum | relative dB
    nconnections: '2'
    type: complex
    update_time: plot_update_s
    wintype: window.WIN_HANN
  states: {}
- name: spectrum_budget
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    gui_hint: views@3:1,1,1,1
    label1: RX
    name: RX spectrum | relative level
    type: complex
    update_time: plot_update_s
    wintype: window.WIN_HANN
  states: {}
- name: spectrum_budget_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: spectrum_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: square_plot_panels
  id: snippet
  parameters:
    code: |
      # Plot layout is a resizable 2x2 grid, not a square-canvas constraint.
      for index in range(self.views.count()):
          layout = getattr(self, "views_grid_layout_"+str(index))
          if layout is not None:
              layout.setColumnStretch(0, 1)
              layout.setColumnStretch(1, 1)
              layout.setRowStretch(1, 1)
              layout.setRowStretch(2, 1)
              # Native sinks otherwise request a large minimum and force scrolling.
              for row in (1, 2):
                  for column in (0, 1):
                      panel = layout.itemAtPosition(row, column).widget()
                      panel.setMinimumSize(0, 0)
                      panel.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.views.setMinimumSize(0, 0)
      self.views.setSizePolicy(Qt.QSizePolicy.Ignored, Qt.QSizePolicy.Ignored)
      self.resize(1180, 900)
    comment: 'UI layout only: resizable 2x2 dashboards.'
    section: main_after_init
  states: {}
- name: symbol_rate
  id: parameter
  parameters:
    label: Symbol rate (symbols/s)
    type: eng_float
    value: 1e6
  states: {}
- name: symbols_link
  id: virtual_sink
  parameters:
    stream_id: rx_symbols
  states: {}
- name: symbols_plot
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: throttle
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: timing_error
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    gui_hint: views@1:2,1,1,1
    name: Clock sync timing error
    size: '512'
    srate: symbol_rate
    type: float
    update_time: plot_update_s
  states: {}
- name: timing_input
  id: virtual_source
  parameters:
    stream_id: timing_error
  states: {}
- name: timing_link
  id: virtual_sink
  parameters:
    stream_id: timing_error
  states: {}
- name: tx_constellation
  id: qtgui_const_sink_x
  parameters:
    alpha1: '0.3'
    alpha3: '0.5'
    color2: '"black"'
    color3: '"dark green"'
    grid: 'True'
    gui_hint: views@0:1,0,1,1
    label1: TX encoded symbols
    label2: Ideal reference
    label3: EVM radius guide (% RMS)
    marker2: '8'
    name: 'TX before RRC: blue symbols / black ideal / green guide'
    nconnections: '3'
    size: '1024'
    type: complex
    update_time: plot_update_s
  states: {}
- name: tx_constellation_reference_1
  id: virtual_source
  parameters:
    stream_id: ideal_points
  states: {}
- name: tx_constellation_reference_2
  id: virtual_source
  parameters:
    stream_id: guide_circles
  states: {}
- name: tx_dbm
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: tx_dbm_link
  id: virtual_sink
  parameters:
    stream_id: sensed_tx_dbm
  states: {}
- name: tx_eye_i
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: tx_eye_i_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@2:1,0,1,1
    label1: TX I | shaped waveform
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: TX_EYE I | TX shaped
  states: {}
- name: tx_eye_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_eye_q
  id: blocks_complex_to_imag
  parameters: {}
  states: {}
- name: tx_eye_q_eye
  id: qtgui_eye_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: views@4:1,0,1,1
    label1: TX Q | shaped waveform
    samp_per_symbol: sps
    size: '1024'
    srate: samp_rate
    type: float
    update_time: plot_update_s
    ylabel: TX_EYE Q | TX shaped
  states: {}
- name: tx_meter_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_milliwatts
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: tx_mw_link
  id: virtual_sink
  parameters:
    stream_id: tx_power_mw
  states: {}
- name: tx_papr
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: tx_peak_dbm
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: tx_peak_mw
  id: blocks_max_xx
  parameters:
    type: float
    vlen: '4096'
    vlen_out: '1'
  states: {}
- name: tx_peak_vectors
  id: blocks_stream_to_vector
  parameters:
    num_items: '4096'
    type: float
  states: {}
- name: tx_plot_link
  id: virtual_sink
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_power
  id: blocks_multiply_const_vxx
  parameters:
    const: tx_amplitude/symbol_rms
    type: complex
  states: {}
- name: tx_power_dbm
  id: parameter
  parameters:
    label: TX average conducted power (dBm)
    type: eng_float
    value: '0'
  states: {}
- name: tx_power_mean
  id: blocks_multiply_const_vxx
  parameters:
    const: 1.0/4096
    type: float
  states: {}
- name: tx_power_sum
  id: blocks_integrate_xx
  parameters:
    decim: '4096'
    type: float
  states: {}
- name: tx_spectrum
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_symbol_chunks
  id: blocks_packed_to_unpacked_xx
  parameters:
    bits_per_chunk: k
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: tx_symbol_diff
  id: digital_diff_encoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '4'
  states: {}
- name: tx_symbol_input
  id: virtual_source
  parameters:
    stream_id: reference
  states: {}
- name: tx_symbols
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: const.points()
  states: {}
- name: tx_time
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_wave_input
  id: virtual_source
  parameters:
    stream_id: tx_iq
  states: {}
- name: tx_waveform
  id: qtgui_time_sink_x
  parameters:
    gui_hint: views@1:1,0,1,1
    name: Clean TX waveform | I/Q
    size: '512'
    srate: samp_rate
    type: complex
    update_time: plot_update_s
  states: {}
- name: unpack_rx
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: unpack_tx
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: unused_timing_states
  id: blocks_null_sink
  parameters:
    num_inputs: '2'
    type: float
  states: {}
- name: views
  id: qtgui_tab_widget
  parameters:
    label0: Constellations
    label1: Waveforms
    label2: I eyes
    label3: Link budget
    label4: Q eyes
    label5: BER / EVM / taps
    num_tabs: '6'
  states: {}
- name: waveform
  id: qtgui_time_sink_x
  parameters:
    gui_hint: views@1:1,1,1,1
    label1: RX I
    label2: RX Q
    label3: TX I
    label4: TX Q
    name: TX and RX waveform | I/Q
    nconnections: '2'
    size: '512'
    srate: samp_rate
    type: complex
    update_time: plot_update_s
  states: {}
- name: waveform_input
  id: virtual_source
  parameters:
    stream_id: rx_iq
  states: {}
- name: xor
  id: blocks_xor_xx
  parameters:
    type: byte
  states: {}
- name: plot_update_s
  id: parameter
  parameters:
    value: '0.5'
    type: eng_float
    label: Plot refresh interval (s)
  states: {}
- name: section_ber_test
  id: note
  parameters:
    note: BER TEST (FIXED LENGTH)
  states: {}
- name: ber_test_bits
  id: parameter
  parameters:
    value: '1000000'
    type: intx
    label: BER test length (compared bits)
  states: {}
- name: ber_test_blocks
  id: variable
  parameters:
    value: max(1, int(ber_test_bits) // 10000)
  states: {}
- name: ber_test_start
  id: variable
  parameters:
    value: '0'
  states: {}
- name: ber_error_weight
  id: variable
  parameters:
    value: '1.0'
  states: {}
- name: ber_test_seconds
  id: variable
  parameters:
    value: (warmup_bits + 10000*ber_test_blocks) / bit_rate
  states: {}
- name: bit_errors_link
  id: virtual_sink
  parameters:
    stream_id: bit_errors
  states: {}
- name: bit_errors_to_ber_test
  id: virtual_source
  parameters:
    stream_id: bit_errors
  states: {}
- name: ber_test_sum_10k
  id: blocks_integrate_xx
  parameters:
    type: float
    decim: '10000'
  states: {}
- name: ber_test_zero
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '0'
  states: {}
- name: ber_test_unit
  id: blocks_add_const_vxx
  parameters:
    type: float
    const: '1'
  states: {}
- name: ber_test_index
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_started
  id: blocks_threshold_ff
  parameters:
    low: ber_test_start + 0.5
    high: ber_test_start + 0.5
    init: '0'
  states: {}
- name: ber_test_done
  id: blocks_threshold_ff
  parameters:
    low: ber_test_start + ber_test_blocks + 0.5
    high: ber_test_start + ber_test_blocks + 0.5
    init: '0'
  states: {}
- name: ber_test_gate
  id: blocks_sub_xx
  parameters:
    type: float
  states: {}
- name: ber_test_gated_errors
  id: blocks_multiply_xx
  parameters:
    type: float
  states: {}
- name: ber_test_error_sum
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_errors
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: ber_error_weight
  states: {}
- name: ber_test_window_sum
  id: iir_filter_xxx
  parameters:
    type: ffd
    fftaps: '[1.0]'
    fbtaps: '[0.0, 1.0]'
  states: {}
- name: ber_test_count
  id: blocks_multiply_const_vxx
  parameters:
    type: float
    const: '10000'
  states: {}
- name: ber_test_ratio
  id: blocks_divide_xx
  parameters:
    type: float
  states: {}
- name: probe_tx_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_tx_peak_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_tx_papr
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_dbm
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_snr
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_rx_ebno
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_evm_rms
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_scale
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_count
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_errors
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_ratio
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: probe_ber_test_index
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: link_table
  id: snippet
  parameters:
    section: main_after_init
    priority: '1'
    code: |
      # Link budget and BER test as a spreadsheet-style table (display only).
      # Values come from stock Probe Signal blocks; edit rows here to change it.
      rows = [
          ('Transmit', 'Average power', self.probe_tx_dbm, 'dBm', 'dB'),
          ('', 'Sampled peak power', self.probe_tx_peak_dbm, 'dBm', 'dB'),
          ('', 'Peak / average', self.probe_tx_papr, 'dB', 'dB'),
          ('Receive', 'Signal + noise power', self.probe_rx_dbm, 'dBm', 'dB'),
          ('', 'SNR (noise over Fs)', self.probe_rx_snr, 'dB', 'dB'),
          ('', 'Eb/N0 per uncoded bit', self.probe_rx_ebno, 'dB', 'dB'),
          ('', 'EVM (decision-directed)', self.probe_evm_rms, '%', 'dB'),
          ('BER', 'Latest 10,000 bits', self.probe_ber_scale, 'errors/bit', 'ber'),
          ('BER test', 'Test length', None, 'bits', "f'{10000 * self.ber_test_blocks:,}'"),
          ('', 'Estimated time', None, 's', "f'{self.ber_test_seconds:.2f}'"),
          ('', 'Status', self.probe_ber_test_count, '', 'status'),
          ('', 'Bits compared', self.probe_ber_test_count, 'bits', 'test_count'),
          ('', 'Bit errors', self.probe_ber_test_errors, 'errors', 'test_errors'),
          ('', 'BER', self.probe_ber_test_ratio, 'errors/bit', 'test_ber'),
      ]
      table = Qt.QTableWidget(len(rows), 4)
      table.setHorizontalHeaderLabels(["Section", "Quantity", "Value", "Unit"])
      table.verticalHeader().setVisible(False)
      table.setEditTriggers(Qt.QAbstractItemView.NoEditTriggers)
      table.setSelectionMode(Qt.QAbstractItemView.NoSelection)
      table.setAlternatingRowColors(True)
      table.setShowGrid(True)
      bold = Qt.QFont(table.font())
      bold.setBold(True)
      for row, (section, quantity, probe, unit, fmt) in enumerate(rows):
          for column, text in ((0, section), (1, quantity), (3, unit)):
              item = Qt.QTableWidgetItem(text)
              if column == 0:
                  item.setFont(bold)
              table.setItem(row, column, item)
          value = Qt.QTableWidgetItem("" if probe else str(eval(fmt)))
          value.setTextAlignment(Qt.Qt.AlignRight | Qt.Qt.AlignVCenter)
          table.setItem(row, 2, value)
      header = table.horizontalHeader()
      header.setSectionResizeMode(Qt.QHeaderView.ResizeToContents)
      header.setStretchLastSection(True)
      test_bits = 10000 * self.ber_test_blocks
      # BER test totals run since the flowchart started; each test is shown relative
      # to the totals frozen when it began (zero for the first test).
      test = dict(base_count=0.0, base_errors=0.0, restarting=False)

      def test_values():
          count = self.probe_ber_test_count.level() - test["base_count"]
          errors = self.probe_ber_test_errors.level() - test["base_errors"]
          return count, errors

      def refresh_link_table():
          count, errors = test_values()
          for row, (section, quantity, probe, unit, fmt) in enumerate(rows):
              if probe is None:
                  continue
              level = probe.level()
              if fmt == "dB":
                  text = f"{level:.2f}"
              elif fmt == "count":
                  text = f"{level:,.0f}"
              elif fmt == "ber":
                  text = f"{level:.3e}"
              elif fmt == "test_count":
                  text = f"{count:,.0f}"
              elif fmt == "test_errors":
                  text = f"{errors:,.0f}"
              elif fmt == "test_ber":
                  text = f"{errors / count:.3e}" if count > 0 else ""
              elif test["restarting"]:
                  text = "restarting"
              else:
                  text = "complete" if count >= test_bits else (
                      "counting" if count > 0 else "waiting for warm-up")
              table.item(row, 2).setText(text)

      def restart_ber_test():
          # 1) Close the test gate so the running totals freeze.
          test["restarting"] = True
          self.set_ber_test_start(1e15)
          Qt.QTimer.singleShot(500, begin_new_test)

      def begin_new_test():
          # 2) Frozen totals become the new zero; the new test starts a quarter
          #    second ahead, so every counted 10,000-bit window is new and the test
          #    covers exactly ber_test_bits bits.
          test["base_count"] = self.probe_ber_test_count.level()
          test["base_errors"] = self.probe_ber_test_errors.level()
          ahead = max(2, int(0.25 * self.bit_rate / 10000))
          self.set_ber_test_start(self.probe_ber_test_index.level() + ahead)
          test["restarting"] = False

      self.restart_ber_test = restart_ber_test
      self.restart_ber_test_button = Qt.QPushButton("Restart BER test")
      self.restart_ber_test_button.clicked.connect(restart_ber_test)
      self.views_grid_layout_3.addWidget(self.restart_ber_test_button, 4, 0, 1, 2)

      self.link_table = table
      self.link_table_timer = Qt.QTimer()
      self.link_table_timer.timeout.connect(refresh_link_table)
      self.link_table_timer.start(int(1000 * self.plot_update_s))
      self.views_grid_layout_3.addWidget(table, 1, 0, 2, 1)
  states: {}
- name: rf_constellation_input
  id: virtual_source
  parameters:
    stream_id: rx_symbols
  states: {}
- name: rf_constellation
  id: qtgui_const_sink_x
  parameters:
    type: complex
    name: Received symbols (after equalizer)
    size: '1024'
    grid: 'True'
    gui_hint: views@3:2,1,1,1
    label1: RX
    alpha1: '0.4'
    update_time: plot_update_s
    legend: 'False'
  states: {}

connections:
- [after_eye_reconstruction, '0', after_i, '0']
- [after_eye_reconstruction, '0', after_q, '0']
- [after_i, '0', after_i_eye, '0']
- [after_input, '0', after_eye_reconstruction, '0']
- [after_q, '0', after_q_eye, '0']
- [before_eq_input, '0', before_eq_constellation, '0']
- [ber_plot_input, '0', ber_history, '0']
- [ber_scale, '0', ber_display, '0']
- [ber_scale, '0', ber_link, '0']
- [channel, '0', rx_iq_link, '0']
- [channel, '0', rx_level, '0']
- [clock_sync, '0', rx_scale, '0']
- [clock_sync, '1', timing_link, '0']
- [clock_sync, '2', unused_timing_states, '0']
- [clock_sync, '3', unused_timing_states, '1']
- [constellation_reference_1, '0', constellation, '1']
- [constellation_reference_2, '0', constellation, '2']
- [decoded_source, '0', diff_decoder, '0']
- [decoder, '0', decoded_link, '0']
- [delay, '0', skip_tx, '0']
- [diff_decoder, '0', unpack_rx, '0']
- [eq_error_trace_input, '0', eq_error_trace, '0']
- [eq_tap_decimator, '0', eq_tap_magnitudes, '0']
- [eq_tap_decimator_input, '0', eq_tap_decimator, '0']
- [eq_tap_magnitudes, '0', eq_tap_plot, '0']
- [equalizer, '0', decoder, '0']
- [equalizer, '0', symbols_link, '0']
- [equalizer, '1', adaptive_tap_vectors_link, '0']
- [errors_float, '0', integrate, '0']
- [evm, '0', evm_per_symbol_link, '0']
- [evm, '0', evm_rms, '0']
- [evm_circles, '0', evm_circles_link, '0']
- [evm_input, '0', evm, '0']
- [evm_meter_history_input, '0', eq_evm_history, '0']
- [evm_plot_input, '0', evm_history, '0']
- [evm_rms, '0', evm_display, '0']
- [evm_rms, '0', evm_link, '0']
- [eye_i, '0', eye, '0']
- [eye_input, '0', eye_i, '0']
- [eye_q, '0', eye_quadrature, '0']
- [eye_q_input, '0', eye_q, '0']
- [ideal_symbols, '0', ideal_symbols_link, '0']
- [integrate, '0', ber_scale, '0']
- [middle_eye_reconstruction, '0', middle_i, '0']
- [middle_eye_reconstruction, '0', middle_q, '0']
- [middle_i, '0', middle_i_eye, '0']
- [middle_input, '0', middle_eye_reconstruction, '0']
- [middle_q, '0', middle_q_eye, '0']
- [modulator, '0', tx_power, '0']
- [peak_input, '0', tx_peak_vectors, '0']
- [random_bytes, '0', modulator, '0']
- [random_bytes, '0', reference_link, '0']
- [reference_source, '0', unpack_tx, '0']
- [rx_ebno_input, '0', rx_ebno, '0']
- [rx_level, '0', clock_sync, '0']
- [rx_meter_input, '0', rx_milliwatts, '0']
- [rx_milliwatts, '0', rx_power_sum, '0']
- [rx_power_mean, '0', rx_dbm, '0']
- [rx_power_sum, '0', rx_power_mean, '0']
- [rx_scale, '0', equalizer, '0']
- [rx_scale, '0', pre_eq_link, '0']
- [rx_snr_input, '0', rx_snr, '0']
- [skip_rx, '0', xor, '0']
- [skip_tx, '0', xor, '1']
- [spectrum_budget_input, '0', spectrum_budget, '0']
- [spectrum_input, '0', spectrum, '0']
- [symbols_plot, '0', constellation, '0']
- [throttle, '0', channel, '0']
- [timing_input, '0', timing_error, '0']
- [tx_constellation_reference_1, '0', tx_constellation, '1']
- [tx_constellation_reference_2, '0', tx_constellation, '2']
- [tx_dbm, '0', tx_dbm_link, '0']
- [tx_dbm, '0', tx_papr, '1']
- [tx_eye_i, '0', tx_eye_i_eye, '0']
- [tx_eye_input, '0', tx_eye_i, '0']
- [tx_eye_input, '0', tx_eye_q, '0']
- [tx_eye_q, '0', tx_eye_q_eye, '0']
- [tx_meter_input, '0', tx_milliwatts, '0']
- [tx_milliwatts, '0', tx_mw_link, '0']
- [tx_milliwatts, '0', tx_power_sum, '0']
- [tx_peak_dbm, '0', tx_papr, '0']
- [tx_peak_mw, '0', tx_peak_dbm, '0']
- [tx_peak_vectors, '0', tx_peak_mw, '0']
- [tx_power, '0', throttle, '0']
- [tx_power, '0', tx_plot_link, '0']
- [tx_power_mean, '0', tx_dbm, '0']
- [tx_power_sum, '0', tx_power_mean, '0']
- [tx_spectrum, '0', spectrum, '1']
- [tx_symbol_chunks, '0', tx_symbol_diff, '0']
- [tx_symbol_diff, '0', tx_symbols, '0']
- [tx_symbol_input, '0', tx_symbol_chunks, '0']
- [tx_symbols, '0', tx_constellation, '0']
- [tx_time, '0', waveform, '1']
- [tx_wave_input, '0', tx_waveform, '0']
- [unpack_rx, '0', skip_rx, '0']
- [unpack_tx, '0', delay, '0']
- [waveform_input, '0', waveform, '0']
- [xor, '0', errors_float, '0']
- [errors_float, '0', bit_errors_link, '0']
- [bit_errors_to_ber_test, '0', ber_test_sum_10k, '0']
- [ber_test_sum_10k, '0', ber_test_zero, '0']
- [ber_test_zero, '0', ber_test_unit, '0']
- [ber_test_unit, '0', ber_test_index, '0']
- [ber_test_index, '0', ber_test_started, '0']
- [ber_test_index, '0', ber_test_done, '0']
- [ber_test_started, '0', ber_test_gate, '0']
- [ber_test_done, '0', ber_test_gate, '1']
- [ber_test_sum_10k, '0', ber_test_gated_errors, '0']
- [ber_test_gate, '0', ber_test_gated_errors, '1']
- [ber_test_gated_errors, '0', ber_test_error_sum, '0']
- [ber_test_error_sum, '0', ber_test_errors, '0']
- [ber_test_gate, '0', ber_test_window_sum, '0']
- [ber_test_window_sum, '0', ber_test_count, '0']
- [ber_test_errors, '0', ber_test_ratio, '0']
- [ber_test_count, '0', ber_test_ratio, '1']
- [tx_dbm, '0', probe_tx_dbm, '0']
- [tx_peak_dbm, '0', probe_tx_peak_dbm, '0']
- [tx_papr, '0', probe_tx_papr, '0']
- [rx_dbm, '0', probe_rx_dbm, '0']
- [rx_snr, '0', probe_rx_snr, '0']
- [rx_ebno, '0', probe_rx_ebno, '0']
- [evm_rms, '0', probe_evm_rms, '0']
- [ber_scale, '0', probe_ber_scale, '0']
- [ber_test_count, '0', probe_ber_test_count, '0']
- [ber_test_errors, '0', probe_ber_test_errors, '0']
- [ber_test_ratio, '0', probe_ber_test_ratio, '0']
- [ber_test_index, '0', probe_ber_test_index, '0']
- [rf_constellation_input, '0', rf_constellation, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
