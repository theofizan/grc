options:
  parameters:
    id: wlan_ofdm_fft
    title: 'Legacy Wi-Fi: visible CP removal and FFT'
    author: Antenna benchmark project
    description: Explicit GNU Radio DATA extraction, CP removal, vectorization and FFT; known-schedule software verification.
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      from antenna_bench.paths import ROOT
      from antenna_bench.math import make_symbols
      import math
  states: {}
- name: rate_index
  id: parameter
  parameters:
    value: '2'
    type: intx
    label: Legacy rate index (0-7)
  states: {}
- name: reference
  id: variable
  parameters:
    value: __import__('scipy.io', fromlist=['loadmat']).loadmat(str(ROOT / ('results/reference/wlan_rate_%d.mat' % rate_index)), squeeze_me=True)
  states: {}
- name: metadata
  id: variable
  parameters:
    value: __import__('json').loads((ROOT / ('results/reference/wlan_rate_%d.json' % rate_index)).read_text())
  states: {}
- name: aligned_capture
  id: blocks_file_source
  parameters:
    type: complex
    file: str(ROOT / ('results/grc/wlan_rate_%d_rx.c64' % rate_index))
    repeat: 'False'
  states: {}
- name: remove_leading_samples
  id: blocks_skiphead
  parameters:
    type: complex
    num_items: metadata['leading_samples']
  states: {}
- name: extract_data_fields
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: int(reference['data_length'])
    n: metadata['packet_samples']+metadata['idle_samples']
    offset: int(reference['data_start'])
  states: {}
- name: remove_cyclic_prefix
  id: blocks_keep_m_in_n
  parameters:
    type: complex
    m: '64'
    n: '80'
    offset: '16'
  states: {}
- name: ofdm_vectors
  id: blocks_stream_to_vector
  parameters:
    type: complex
    num_items: '64'
  states: {}
- name: fft_64
  id: fft_vxx
  parameters:
    type: complex
    fft_size: '64'
    forward: 'True'
    window: '[]'
    shift: 'False'
  states: {}
- name: fft_capture
  id: blocks_file_sink
  parameters:
    type: complex
    file: str(ROOT / ('results/grc/wlan_rate_%d_fft.c64' % rate_index))
    vlen: '64'
  states: {}
- name: scope
  id: note
  parameters:
    note: |-
      KNOWN-SCHEDULE OFDM EXTRACTION: timing/rate/length are supplied; this is not autonomous packet
      acquisition.
  states: {}
- name: convention
  id: note
  parameters:
    note: |-
      DATA FFT window starts after all 16 CP samples. Forward FFT, no shift, no window; all 64 bins
      stored.
  states: {}
- name: analysis
  id: note
  parameters:
    note: |-
      Run scripts/validate_grc_fft.py. Channel estimation, EVM, and demapping are independently checked
      offline.
  states: {}
- name: layout_controls
  id: note
  parameters:
    note: RUN PARAMETERS
  states: {}
- name: layout_constants
  id: note
  parameters:
    note: DERIVED CONSTANTS
  states: {}
- name: layout_0
  id: note
  parameters:
    note: CAPTURE AND KNOWN-SCHEDULE DATA EXTRACTION
  states: {}
- name: layout_1
  id: note
  parameters:
    note: OFDM DEMODULATION AND CAPTURE
  states: {}
- name: layout_notes
  id: note
  parameters:
    note: MODEL ASSUMPTIONS AND OPERATING NOTES
  states: {}

connections:
- [aligned_capture, '0', remove_leading_samples, '0']
- [remove_leading_samples, '0', extract_data_fields, '0']
- [extract_data_fields, '0', remove_cyclic_prefix, '0']
- [remove_cyclic_prefix, '0', ofdm_vectors, '0']
- [ofdm_vectors, '0', fft_64, '0']
- [fft_64, '0', fft_capture, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
