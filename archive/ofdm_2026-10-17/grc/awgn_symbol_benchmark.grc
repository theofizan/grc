options:
  parameters:
    id: awgn_symbol_benchmark
    title: 'Uncoded BER and EVM: aligned symbol AWGN'
    author: Antenna benchmark project
    description: Exact uncoded-theory diagnostic with finite captures and external metrics. Not an 802.11 PHY.
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      from antenna_bench.paths import ROOT
      from antenna_bench.math import make_symbols
      import math
  states: {}
- name: order
  id: parameter
  parameters:
    value: '16'
    type: intx
    label: Constellation order M
  states: {}
- name: ebno_db
  id: parameter
  parameters:
    value: '8'
    type: eng_float
    label: Uncoded Eb/N0 (dB)
  states: {}
- name: symbol_count
  id: parameter
  parameters:
    value: '100000'
    type: intx
    label: Number of symbols
  states: {}
- name: seed
  id: parameter
  parameters:
    value: '20261016'
    type: intx
    label: Noise/reference seed
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: math.sqrt(1/(math.log2(order)*10**(ebno_db/10)))
  states: {}
- name: reference_symbols
  id: blocks_vector_source_x
  parameters:
    type: complex
    vector: make_symbols(order, symbol_count, seed).tolist()
    repeat: 'False'
  states: {}
- name: complex_awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_voltage
    seed: seed+1
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: received_symbols
  id: blocks_file_sink
  parameters:
    type: complex
    file: str(ROOT / 'results/grc/symbol_rx.c64')
  states: {}
- name: transmitted_symbols
  id: blocks_file_sink
  parameters:
    type: complex
    file: str(ROOT / 'results/grc/symbol_tx.c64')
  states: {}
- name: scope
  id: note
  parameters:
    note: 'UNCODED SYMBOL-RATE DIAGNOSTIC: perfect alignment, Es=1, no RF waveform or FEC.'
  states: {}
- name: noise
  id: note
  parameters:
    note: E|n|^2 = noise_voltage^2 = 1/(log2(M)*EbNo). Complex Gaussian convention is validated.
  states: {}
- name: analysis
  id: note
  parameters:
    note: |-
      Run scripts/analyze_symbols.py then MATLAB validate_python_results(results/grc). See
      docs/FLOWGRAPHS.md.
  states: {}
- name: layout_controls
  id: note
  parameters:
    note: RUN PARAMETERS
  states: {}
- name: layout_constants
  id: note
  parameters:
    note: DERIVED CONSTANTS
  states: {}
- name: layout_0
  id: note
  parameters:
    note: TRANSMIT REFERENCE
  states: {}
- name: layout_1
  id: note
  parameters:
    note: AWGN CHANNEL AND CAPTURE
  states: {}
- name: layout_notes
  id: note
  parameters:
    note: MODEL ASSUMPTIONS AND OPERATING NOTES
  states: {}

connections:
- [reference_symbols, '0', add_noise, '0']
- [complex_awgn, '0', add_noise, '1']
- [reference_symbols, '0', transmitted_symbols, '0']
- [add_noise, '0', received_symbols, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
