options:
  parameters:
    id: usrp_wifi_rx
    title: USRP legacy Wi-Fi finite raw IQ capture
    author: Antenna benchmark project
    description: UHD hardware integration graph. RF/streaming, timed acquisition and antenna control require hardware commissioning.
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      from antenna_bench.paths import ROOT
      from antenna_bench.math import make_symbols
      import math
  states: {}
- name: center_frequency
  id: parameter
  parameters:
    value: '5180000000.0'
    type: eng_float
    label: RF center frequency (Hz)
  states: {}
- name: gain_db
  id: parameter
  parameters:
    value: '20'
    type: eng_float
    label: USRP gain (dB)
  states: {}
- name: device_args
  id: parameter
  parameters:
    value: type=x300,addr=192.168.10.2
    type: str
    label: UHD device address
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: capture_samples
  id: parameter
  parameters:
    value: '2000000'
    type: intx
    label: Complex samples to capture
  states: {}
- name: usrp_source
  id: uhd_usrp_source
  parameters:
    type: fc32
    otw: sc16
    dev_addr: device_args
    sync: none
    clock_source0: internal
    samp_rate: sample_rate
    center_freq0: center_frequency
    gain0: gain_db
    ant0: '"RX2"'
  states: {}
- name: finite_capture
  id: blocks_head
  parameters:
    type: complex
    num_items: capture_samples
  states: {}
- name: raw_iq
  id: blocks_file_sink
  parameters:
    type: complex
    file: str(ROOT / 'results/grc/usrp_rx.c64')
  states: {}
- name: scope
  id: note
  parameters:
    note: |-
      HARDWARE GRAPH: compiled only; not radio-tested. Configure actual daughterboard, addresses, ports
      and gains.
  states: {}
- name: steering
  id: note
  parameters:
    note: Steer/await ready/settle BEFORE starting capture; keep beam fixed throughout every scored packet.
  states: {}
- name: metadata
  id: note
  parameters:
    note: |-
      Standalone graph does not archive UHD errors/settings or enforce steering. Paper runs require the
      documented acquisition ledger.
  states: {}
- name: layout_controls
  id: note
  parameters:
    note: RUN PARAMETERS
  states: {}
- name: layout_constants
  id: note
  parameters:
    note: DERIVED CONSTANTS
  states: {}
- name: layout_0
  id: note
  parameters:
    note: SISO RECEIVER AND FINITE CAPTURE
  states: {}
- name: layout_notes
  id: note
  parameters:
    note: MODEL ASSUMPTIONS AND OPERATING NOTES
  states: {}

connections:
- [usrp_source, '0', finite_capture, '0']
- [finite_capture, '0', raw_iq, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
