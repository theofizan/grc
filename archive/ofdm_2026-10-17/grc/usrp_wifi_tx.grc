options:
  parameters:
    id: usrp_wifi_tx
    title: USRP legacy Wi-Fi transmit reference IQ
    author: Antenna benchmark project
    description: UHD hardware integration graph. RF/streaming, timed acquisition and antenna control require hardware commissioning.
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      from antenna_bench.paths import ROOT
      from antenna_bench.math import make_symbols
      import math
  states: {}
- name: center_frequency
  id: parameter
  parameters:
    value: '5180000000.0'
    type: eng_float
    label: RF center frequency (Hz)
  states: {}
- name: gain_db
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: USRP gain (dB)
  states: {}
- name: device_args
  id: parameter
  parameters:
    value: type=x300,addr=192.168.10.2
    type: str
    label: UHD device address
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: rate_index
  id: parameter
  parameters:
    value: '2'
    type: intx
    label: Legacy rate index (0-7)
  states: {}
- name: wifi_reference
  id: blocks_file_source
  parameters:
    type: complex
    file: str(ROOT / ('results/reference/wlan_rate_%d_tx.c64' % rate_index))
    repeat: 'False'
  states: {}
- name: usrp_sink
  id: uhd_usrp_sink
  parameters:
    type: fc32
    otw: sc16
    dev_addr: device_args
    sync: none
    clock_source0: internal
    samp_rate: sample_rate
    center_freq0: center_frequency
    gain0: gain_db
    ant0: '"TX/RX"'
  states: {}
- name: scope
  id: note
  parameters:
    note: |-
      HARDWARE GRAPH: compiled only; not radio-tested. Configure actual daughterboard, addresses, ports
      and gains.
  states: {}
- name: steering
  id: note
  parameters:
    note: Steer/await ready/settle BEFORE starting capture; keep beam fixed throughout every scored packet.
  states: {}
- name: metadata
  id: note
  parameters:
    note: |-
      Standalone graph does not archive UHD errors/settings or enforce steering. Paper runs require the
      documented acquisition ledger.
  states: {}
- name: layout_controls
  id: note
  parameters:
    note: RUN PARAMETERS
  states: {}
- name: layout_constants
  id: note
  parameters:
    note: DERIVED CONSTANTS
  states: {}
- name: layout_0
  id: note
  parameters:
    note: SISO TRANSMITTER
  states: {}
- name: layout_notes
  id: note
  parameters:
    note: MODEL ASSUMPTIONS AND OPERATING NOTES
  states: {}

connections:
- [wifi_reference, '0', usrp_sink, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
