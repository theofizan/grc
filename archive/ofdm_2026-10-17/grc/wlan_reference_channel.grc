options:
  parameters:
    id: wlan_reference_channel
    title: 'Legacy Wi-Fi reference: finite IQ AWGN replay'
    author: Antenna benchmark project
    description: Replay actual MATLAB-generated non-HT PPDU samples. See docs/FLOWGRAPHS.md for export and analysis.
    generate_options: no_gui
    output_language: python
    run_options: run
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      from antenna_bench.paths import ROOT
      from antenna_bench.math import make_symbols
      import math
  states: {}
- name: rate_index
  id: parameter
  parameters:
    value: '2'
    type: intx
    label: Legacy rate index (0-7)
  states: {}
- name: snr_db
  id: parameter
  parameters:
    value: '25'
    type: eng_float
    label: Active DATA sample SNR (dB)
  states: {}
- name: sample_rate
  id: variable
  parameters:
    value: 20e6
  states: {}
- name: tx_file
  id: variable
  parameters:
    value: str(ROOT / ('results/reference/wlan_rate_%d_tx.c64' % rate_index))
  states: {}
- name: noise_voltage
  id: variable
  parameters:
    value: math.sqrt(__import__('json').loads((ROOT / ('results/reference/wlan_rate_%d.json' % rate_index)).read_text())['active_time_power']/10**(snr_db/10))
  states: {}
- name: wifi_reference
  id: blocks_file_source
  parameters:
    type: complex
    file: tx_file
    repeat: 'False'
  states: {}
- name: complex_awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_voltage
    seed: '20261017'
  states: {}
- name: add_noise
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: wifi_capture
  id: blocks_file_sink
  parameters:
    type: complex
    file: str(ROOT / ('results/grc/wlan_rate_%d_rx.c64' % rate_index))
  states: {}
- name: scope
  id: note
  parameters:
    note: WLAN TOOLBOX REFERENCE PPDU -> GNU RADIO AWGN -> RAW IQ. No packet/coding approximation.
  states: {}
- name: axis
  id: note
  parameters:
    note: |-
      snr_db is active-DATA time-sample SNR, not EbNo. Idle samples are excluded from signal-power
      calibration.
  states: {}
- name: analysis
  id: note
  parameters:
    note: |-
      Offline Python: known-schedule pre-FEC BER/EVM. MATLAB: independent equalizer, decoder and post-FEC
      BER.
  states: {}
- name: layout_controls
  id: note
  parameters:
    note: RUN PARAMETERS
  states: {}
- name: layout_constants
  id: note
  parameters:
    note: DERIVED CONSTANTS
  states: {}
- name: layout_0
  id: note
  parameters:
    note: REFERENCE WAVEFORM
  states: {}
- name: layout_1
  id: note
  parameters:
    note: AWGN CHANNEL AND CAPTURE
  states: {}
- name: layout_notes
  id: note
  parameters:
    note: MODEL ASSUMPTIONS AND OPERATING NOTES
  states: {}

connections:
- [wifi_reference, '0', add_noise, '0']
- [complex_awgn, '0', add_noise, '1']
- [add_noise, '0', wifi_capture, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
