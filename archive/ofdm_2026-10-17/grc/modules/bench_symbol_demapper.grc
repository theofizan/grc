options:
  parameters:
    id: bench_symbol_demapper
    title: Hard decisions | IQ to unpacked bits
    category: '[Antenna benchmark]'
    generate_options: hb
    output_language: python
    description: Editable stock-block stage. See docs/MODULAR_FLOWGRAPHS.md.
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from antenna_bench.paths import ROOT
      from antenna_bench.live import test_bits, wlan_reference, burst_waveform, reference_symbols, parse_taps
      from antenna_bench.wlan import wlan_constellation
      from gnuradio import digital
  states: {}
- name: k
  id: variable
  parameters:
    value: int(math.log2(order))
  states: {}
- name: constellation_object
  id: variable
  parameters:
    value: digital.constellation_calcdist(wlan_constellation(order).tolist(),list(range(order)),1,1,digital.constellation.NO_NORMALIZATION).base()
  states: {}
- name: order
  id: parameter
  parameters:
    value: '16'
    type: intx
    label: Constellation order M
  states: {}
- name: demap
  id: digital_constellation_decoder_cb
  parameters:
    constellation: constellation_object
  states: {}
- name: rx_bits
  id: blocks_unpack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: input_stream
  id: pad_source
  parameters:
    label: samples
    type: complex
  states: {}
- name: output_stream
  id: pad_sink
  parameters:
    label: bits
    type: byte
  states: {}
- name: contract
  id: note
  parameters:
    note: 'STREAM CONTRACT: complex64 samples -> unpacked 0/1 bytes. Edit this module, generate it, then regenerate its parent lab.'
  states: {}

connections:
- [demap, '0', rx_bits, '0']
- [input_stream, '0', demap, '0']
- [rx_bits, '0', output_stream, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
