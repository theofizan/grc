options:
  parameters:
    id: bench_scalar_channel
    title: SISO scalar channel | loss + AWGN
    category: '[Antenna benchmark]'
    generate_options: hb
    output_language: python
    description: Editable stock-block stage. See docs/MODULAR_FLOWGRAPHS.md.
  states: {}

blocks:
- name: channel_gain
  id: parameter
  parameters:
    value: '1'
    type: eng_float
    label: channel_gain
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    value: '0.1'
    type: eng_float
    label: noise_voltage
  states: {}
- name: noise_seed
  id: parameter
  parameters:
    value: '20261017'
    type: intx
    label: noise_seed
  states: {}
- name: siso_path
  id: blocks_multiply_const_vxx
  parameters:
    type: complex
    const: channel_gain
  states: {}
- name: awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_voltage
    seed: noise_seed
  states: {}
- name: channel_output
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: input_stream
  id: pad_source
  parameters:
    label: samples
    type: complex
  states: {}
- name: output_stream
  id: pad_sink
  parameters:
    label: samples
    type: complex
  states: {}
- name: contract
  id: note
  parameters:
    note: 'STREAM CONTRACT: complex64 samples -> complex64 samples. Edit this module, generate it, then regenerate its parent lab.'
  states: {}

connections:
- [siso_path, '0', channel_output, '0']
- [awgn, '0', channel_output, '1']
- [input_stream, '0', siso_path, '0']
- [channel_output, '0', output_stream, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
