options:
  parameters:
    id: bench_symbol_mapper
    title: Symbol mapper | unpacked bits to IQ
    category: '[Antenna benchmark]'
    generate_options: hb
    output_language: python
    description: Editable stock-block stage. See docs/MODULAR_FLOWGRAPHS.md.
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from antenna_bench.paths import ROOT
      from antenna_bench.live import test_bits, wlan_reference, burst_waveform, reference_symbols, parse_taps
      from antenna_bench.wlan import wlan_constellation
      from gnuradio import digital
  states: {}
- name: k
  id: variable
  parameters:
    value: int(math.log2(order))
  states: {}
- name: order
  id: parameter
  parameters:
    value: '16'
    type: intx
    label: Constellation order M
  states: {}
- name: pack_bits
  id: blocks_pack_k_bits_bb
  parameters:
    k: k
  states: {}
- name: mapper
  id: digital_chunks_to_symbols_xx
  parameters:
    in_type: byte
    out_type: complex
    symbol_table: wlan_constellation(order).tolist()
    dimension: '1'
  states: {}
- name: input_stream
  id: pad_source
  parameters:
    label: bits
    type: byte
  states: {}
- name: output_stream
  id: pad_sink
  parameters:
    label: samples
    type: complex
  states: {}
- name: contract
  id: note
  parameters:
    note: 'STREAM CONTRACT: unpacked 0/1 bytes -> complex64 samples. Edit this module, generate it, then regenerate its parent lab.'
  states: {}

connections:
- [pack_bits, '0', mapper, '0']
- [input_stream, '0', pack_bits, '0']
- [mapper, '0', output_stream, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
