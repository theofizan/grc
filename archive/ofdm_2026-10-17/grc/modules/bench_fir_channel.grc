options:
  parameters:
    id: bench_fir_channel
    title: SISO channel | FIR + CFO + AWGN
    category: '[Antenna benchmark]'
    generate_options: hb
    output_language: python
    description: Editable stock-block stage. See docs/MODULAR_FLOWGRAPHS.md.
  states: {}

blocks:
- name: project_imports
  id: import
  parameters:
    imports: |-
      import math
      import numpy as np
      from antenna_bench.paths import ROOT
      from antenna_bench.live import test_bits, wlan_reference, burst_waveform, reference_symbols, parse_taps
      from antenna_bench.wlan import wlan_constellation
      from gnuradio import digital
  states: {}
- name: channel_gain
  id: parameter
  parameters:
    value: '1'
    type: eng_float
    label: channel_gain
  states: {}
- name: channel_taps
  id: parameter
  parameters:
    value: 1+0j
    type: str
    label: Causal SISO FIR taps
  states: {}
- name: cfo_hz
  id: parameter
  parameters:
    value: '0'
    type: eng_float
    label: Carrier offset (Hz)
  states: {}
- name: sample_rate
  id: parameter
  parameters:
    value: '20000000.0'
    type: eng_float
    label: sample_rate
  states: {}
- name: noise_voltage
  id: parameter
  parameters:
    value: '0.1'
    type: eng_float
    label: noise_voltage
  states: {}
- name: noise_seed
  id: parameter
  parameters:
    value: '20261017'
    type: intx
    label: noise_seed
  states: {}
- name: siso_fir
  id: fir_filter_xxx
  parameters:
    type: ccc
    decim: '1'
    taps: '[channel_gain*t for t in parse_taps(channel_taps)]'
  states: {}
- name: carrier_offset
  id: blocks_rotator_cc
  parameters:
    phase_inc: 2*math.pi*cfo_hz/sample_rate
  states: {}
- name: awgn
  id: analog_noise_source_x
  parameters:
    type: complex
    noise_type: analog.GR_GAUSSIAN
    amp: noise_voltage
    seed: noise_seed
  states: {}
- name: channel_output
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: input_stream
  id: pad_source
  parameters:
    label: samples
    type: complex
  states: {}
- name: output_stream
  id: pad_sink
  parameters:
    label: samples
    type: complex
  states: {}
- name: contract
  id: note
  parameters:
    note: 'STREAM CONTRACT: complex64 samples -> complex64 samples. Edit this module, generate it, then regenerate its parent lab.'
  states: {}

connections:
- [siso_fir, '0', carrier_offset, '0']
- [carrier_offset, '0', channel_output, '0']
- [awgn, '0', channel_output, '1']
- [input_stream, '0', siso_fir, '0']
- [channel_output, '0', output_stream, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
